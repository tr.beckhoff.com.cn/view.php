TYPE camming_state :
(
	state_init,
	state_power,
	state_forward,
	state_pre_table1,
	state_camming1,
	camming_status,		
	state_error,
	state_reset
)INT;
END_TYPE
