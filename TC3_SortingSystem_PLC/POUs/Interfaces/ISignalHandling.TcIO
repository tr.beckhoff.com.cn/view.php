INTERFACE ISignalHandling

METHOD M_SetOutput
VAR_INPUT
END_VAR
END_METHOD

END_INTERFACE
