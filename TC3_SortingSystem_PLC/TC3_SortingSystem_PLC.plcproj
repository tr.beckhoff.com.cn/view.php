// TwinCAT 3 PLC project TC3_SortingSystem_PLC
// libraries:
//   Tc2_MC2, * (Beckhoff Automation GmbH)
//   Tc2_Standard, * (Beckhoff Automation GmbH)
//   Tc2_System, * (Beckhoff Automation GmbH)
//   Tc3_Interfaces, * (Beckhoff Automation GmbH)
//   Tc3_Module, * (Beckhoff Automation GmbH)
// project tree:
//   DUTs/Internal PackAL/ E_PMLState.TcDUT, E_PMLUnitMode.TcDUT, Machine_REF.TcDUT
//   / PlcTask.TcTTO, Visualization Manager.TcVMO
//   POUs/Cylinder/ FB_Cylinder.TcPOU, FB_CylinderDiag.TcPOU, FB_CylinderTemp.TcPOU, FB_CylinderTempDiag.TcPOU, FB_CylinderTempRecord.TcPOU
//   POUs/ FB_Visu.TcPOU, MAIN.TcPOU
//   POUs/Interfaces/ ICylinder.TcIO, ISignalHandling.TcIO
//   POUs/Internal PackAL/ PS_PackML_StateMachine_Auto.TcPOU, PS_PackML_StateMachine_Maintenance.TcPOU, PS_PackML_StateMachine_Manual.TcPOU, PS_PackML_StateMachine_SemiAuto.TcPOU, PS_UnitModeManager.TcPOU
//   POUs/Modules/ FB_Module.TcPOU, FB_SeparatingModule.TcPOU, FB_SortingModule.TcPOU
//   POUs/Signal handling/ FB_SignalHandling.TcPOU, FB_SignalHandlingDelay.TcPOU, FB_SignalHandlingDelayEdges.TcPOU, FB_SignalHandlingIntern.TcPOU
//   POUs/Axis/ FB_Axis.TcPOU
//   VISUs/ GlobalTextList.TcGTLO, Visu_SortingSystem.TcVIS (unreadable)
// (motion and I/O tree: see PLC project tc3_sortingsystem_simu)
// real-time tasks:
//   TASK PlcTask: cycle T#10ms, priority 20, ADS port 350
//   TASK PlcTask_Simu: cycle T#10ms, priority 21, ADS port 351
// variable links:
//   TC3_SortingSystem_PLC/TC3_SortingSystem_PLC Instance <-> NC-Task 1 SAF/Axes/Axis MetalSorting
//     PlcTask Outputs/MAIN.fbMetalSorting.fbAxis.AxisRef.PlcToNc <-> Inputs/Axis MetalSorting_FromPlc
//     PlcTask Inputs/MAIN.fbMetalSorting.fbAxis.AxisRef.NcToPlc <-> Outputs/Axis MetalSorting_ToPlc
//   TC3_SortingSystem_PLC/TC3_SortingSystem_PLC Instance <-> NC-Task 1 SAF/Axes/Axis PlasticSorting
//     PlcTask Outputs/MAIN.fbPlasticSorting.fbAxis.AxisRef.PlcToNc <-> Inputs/Axis PlasticSorting_FromPlc
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbAxis.AxisRef.NcToPlc <-> Outputs/Axis PlasticSorting_ToPlc
//   TC3_SortingSystem_PLC/TC3_SortingSystem_PLC Instance <-> NC-Task 1 SAF/Axes/Axis Separating
//     PlcTask Outputs/MAIN.fbSeparateModule.fbAxis.AxisRef.PlcToNc <-> Inputs/Axis Separating_FromPlc
//     PlcTask Inputs/MAIN.fbSeparateModule.fbAxis.AxisRef.NcToPlc <-> Outputs/Axis Separating_ToPlc
//   TC3_SortingSystem_PLC/TC3_SortingSystem_PLC Instance <-> TC3_SortingSystem_Simu/TC3_SortingSystem_Simu Instance
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTemp.lrTempCurrent <-> PlcTask_Simu Outputs/MAIN_Simu.lrClampTempCurrent
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempDiag.lrTempMax <-> PlcTask_Simu Outputs/MAIN_Simu.lrClampTempMax
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempRecord.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempRecord.lrTempCurrent <-> PlcTask_Simu Outputs/MAIN_Simu.lrClampTempCurrent
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrier.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTemp.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTempDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTempDiag.lrTempCurrent <-> PlcTask_Simu Outputs/MAIN_Simu.lrBarrierTemp
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinder.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtBase
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTempRecord.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtWork
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderTemp.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtBase
//     PlcTask Outputs/MAIN.fbVisu.lrYClamp <-> PlcTask_Simu Inputs/MAIN_Simu.lrYClamp
//     PlcTask Outputs/MAIN.fbVisu.lrYBarrier <-> PlcTask_Simu Inputs/MAIN_Simu.lrYBarrier
//     PlcTask Outputs/MAIN.fbVisu.lrYMetal <-> PlcTask_Simu Inputs/MAIN_Simu.lrYMetal
//     PlcTask Outputs/MAIN.fbVisu.lrYPlastic <-> PlcTask_Simu Inputs/MAIN_Simu.lrYPlastic
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderTempDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtWork
//     PlcTask Outputs/MAIN.fbVisu.lrBoxX <-> PlcTask_Simu Inputs/MAIN_Simu.lrBoxX
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbSensorDelay.bInput <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticSensor
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinder.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtWork
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderTempRecord.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtBase
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtWork
//     PlcTask Outputs/MAIN.fbVisu.lrBoxY <-> PlcTask_Simu Inputs/MAIN_Simu.lrBoxY
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderTemp.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtWork
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderTempDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClamp.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTemp.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrier.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTemp.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtBase
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTempRecord.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtBase
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderTempDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtBase
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderTempRecord.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtWork
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinder.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtBase
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderDiag.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtBase
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderTemp.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtBase
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderTempRecord.bAtBasePos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtBase
//     PlcTask Inputs/MAIN.fbVisu.bBarrierSensor <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierSensor
//     PlcTask Inputs/MAIN.fbSeparateModule.fbSensor.bInput <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierSensor
//     PlcTask Inputs/MAIN.fbVisu.bPlasticSensor <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticSensor
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClamp.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTemp.lrTempCurrent <-> PlcTask_Simu Outputs/MAIN_Simu.lrBarrierTemp
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTempRecord.lrTempCurrent <-> PlcTask_Simu Outputs/MAIN_Simu.lrBarrierTemp
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTemp.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempDiag.lrTempCurrent <-> PlcTask_Simu Outputs/MAIN_Simu.lrClampTempCurrent
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempDiag.lrTempMin <-> PlcTask_Simu Outputs/MAIN_Simu.lrClampTempMin
//     PlcTask Inputs/MAIN.fbSeparateModule.fbClampTempRecord.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bClampAtWork
//     PlcTask Inputs/MAIN.fbSeparateModule.fbBarrierTempDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bBarrierAtWork
//     PlcTask Inputs/MAIN.fbMetalSorting.fbSensorDelay.bInput <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalSensor
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinder.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtWork
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtWork
//     PlcTask Outputs/MAIN.bReset <-> PlcTask_Simu Inputs/MAIN_Simu.bReset
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderTemp.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtWork
//     PlcTask Inputs/MAIN.fbMetalSorting.fbCylinderTempRecord.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalAtWork
//     PlcTask Inputs/MAIN.fbPlasticSorting.fbCylinderTempDiag.bAtWorkPos <-> PlcTask_Simu Outputs/MAIN_Simu.bPlasticAtWork
//     PlcTask Inputs/MAIN.fbVisu.bMetalSensor <-> PlcTask_Simu Outputs/MAIN_Simu.bMetalSensor

CONFIGURATION TC3_SortingSystem_PLC
    RESOURCE PLC ON TwinCAT3
        TASK PlcTask(INTERVAL := T#10ms, PRIORITY := 20);
        PROGRAM MAIN WITH PlcTask : MAIN;
    END_RESOURCE
END_CONFIGURATION

// ---- DUTs/Internal PackAL/E_PMLState.TcDUT
TYPE E_PMLState : (
(* states according to PackTags v3.0 *)
	ePMLState_UNDEFINED		:=  0,
	ePMLState_CLEARING 		:=  1,
	ePMLState_STOPPED 		:=  2,
	ePMLState_STARTING 		:=  3,
	ePMLState_IDLE 			:=  4,
	ePMLState_SUSPENDED 	:=  5,
	ePMLState_EXECUTE 		:=  6,
	ePMLState_STOPPING	 	:=  7,
	ePMLState_ABORTING 		:=  8,
	ePMLState_ABORTED 		:=  9,
	ePMLState_HOLDING 		:= 10,
	ePMLState_HELD 			:= 11,
	ePMLState_UNHOLDING 	:= 12,
	ePMLState_SUSPENDING 	:= 13,
	ePMLState_UNSUSPENDING 	:= 14,
	ePMLState_RESETTING 	:= 15,
	ePMLState_COMPLETING 	:= 16,
	ePMLState_COMPLETE	 	:= 17
);
END_TYPE

// ---- DUTs/Internal PackAL/E_PMLUnitMode.TcDUT
TYPE E_PMLUnitMode : (
	ePMLUnitMode_UNDEFINED		:=  0,
	ePMLUnitMode_AUTOMATIC		:=  1,
	ePMLUnitMode_MAINTENANCE 	:=  2,
	ePMLUnitMode_MANUAL 		:=  3,
	ePMLUnitMode_SEMIAUTOMATIC	:=  4,
	ePMLUnitMode_DRYRUN			:=  5,
	ePMLUnitMode_USERMODE1		:=  6,
	ePMLUnitMode_USERMODE2		:=  7,
	ePMLUnitMode_IDLE 			:=  8,
	ePMLUnitMode_ESTOP 			:=  9
);
END_TYPE

// ---- DUTs/Internal PackAL/Machine_REF.TcDUT
TYPE Machine_REF :
STRUCT
	test : BOOL;
END_STRUCT
END_TYPE

// ---- POUs/Interfaces/ICylinder.TcIO
INTERFACE ICylinder

METHOD M_MoveToBase : BOOL
VAR_INPUT
END_VAR
END_METHOD

METHOD M_MoveToWork : BOOL
VAR_INPUT
END_VAR
END_METHOD

METHOD M_Reset
VAR_INPUT
END_VAR
END_METHOD

METHOD M_StateMachine : BOOL
VAR_INPUT
	bBasePosReq		: BOOL;
	bWorkPosReq		: BOOL;
END_VAR
END_METHOD

PROPERTY P_AtBasePos : BOOL
GET
END_GET
SET
END_SET
END_PROPERTY

PROPERTY P_AtWorkPos : BOOL
GET
END_GET
SET
END_SET
END_PROPERTY

PROPERTY P_ToWork : BOOL
GET
END_GET
SET
END_SET
END_PROPERTY

END_INTERFACE

// ---- POUs/Interfaces/ISignalHandling.TcIO
INTERFACE ISignalHandling

METHOD M_SetOutput
VAR_INPUT
END_VAR
END_METHOD

END_INTERFACE

// ---- POUs/MAIN.TcPOU
PROGRAM MAIN
VAR
	bError						: BOOL;					// True if modules have errors
		(***** Axis variable *****)
	lrAxisVelo					: LREAL;
		
		(***** Variables of state machine *****)
	bStarted					: BOOL;					// True if state machine is in state EXECUTE
	bStopped					: BOOL;					// True if state machine is in state STOPPED
	bReset						AT %Q*: BOOL;			// True if state machine is in state RESETTING
	bAborted					: BOOL;					// True if state machine is in state ABORTED
	bIdle						: BOOL;					// True if state machine is in state IDLE
	bAuto						: BOOL;					// True if state machine is in mode AUTOMATIC
	bSemi						: BOOL;					// True if state machine is in mode SEMIAUTOMATIC
	bManual						: BOOL;					// True if state machine is in mode MANUAL
	bMaintenance				: BOOL;					// True if state machine is in mode MAINTENANCE
	bStartButtonOff				: BOOL;					// To turn off start button

(* ========================== Function block instances =============================== *)

		(**** Machine elements *****)
	fbSeparateModule			: FB_SeparatingModule;			// Separating module
	fbMetalSorting				: FB_SortingModule;				// Module that sorts metal boxes
	fbPlasticSorting			: FB_SortingModule;				// Module that sorts plastic boxes
	fbComprAir					: FB_SignalHandlingIntern;		// Compressed air
	fbPowerSupply				: FB_SignalHandlingIntern;		// Power supply
	fbVisu						: FB_Visu;						// Visualization

		(***** Buttons *****)
	fbButtonStart				: FB_SignalHandlingIntern;		// Button to start the machine
	fbButtonStop				: FB_SignalHandlingIntern;		// Button to stop the machine
	fbButtonReset				: FB_SignalHandlingIntern;		// Button to reset the machine
	fbButtonAbort				: FB_SignalHandlingIntern;		// Button to abort the machine
	fbButtonAuto				: FB_SignalHandlingIntern;		// Button to change machine mode to AUTOMATIC
	fbButtonSemi				: FB_SignalHandlingIntern;		// Button to change machine mode to SEMI-AUTOMATIC
	fbButtonManual				: FB_SignalHandlingIntern;		// Button to change machine mode to MANUAL
	fbButtonMaintenance			: FB_SignalHandlingIntern;		// Button to change machine mode to MAINTENANCE
	fbButtonPower				: FB_SignalHandlingIntern;		// Button to control power supply
	fbButtonComprAir			: FB_SignalHandlingIntern;		// Button to control compressed air

(* ========================== COMMON VARIABLES =============================== *)	

		(***** State machine *****)
	fbStateMachineAuto			: PS_PackML_StateMachine_Auto;			// State machine for mode AUTOMATIC
	fbStateMachineSemiAuto		: PS_PackML_StateMachine_SemiAuto;		// State machine for mode SEMI-AUTOMATIC
	fbStateMachineManual		: PS_PackML_StateMachine_Manual;		// State machine for mode MANUAL
	fbStateMachineMaintenance	: PS_PackML_StateMachine_Maintenance;	// State machine for mode MAINTENANCE
	
	ePMLUnitMode				: E_PMLUnitMode := ePMLUnitMode_IDLE;	// Current mode
	ePMLUnitModeRequested		: E_PMLUnitMode;						// Requested mode
	fbUnitModeManager			: PS_UnitModeManager;					// Mode manager
	ePMLState					: E_PMLState := ePMLState_IDLE;			// Current state
	ePMLStateRequested			: E_PMLState;							// Requested state
	refMachine					: Machine_REF;
	
		(* Common variables *)
	bManualAxisEnable			: BOOL;							// True if it is allowed to move manually axis
	rtrigStart					: R_TRIG;						// To diagnose rising edge of start button
	rtrigSeparated				: R_TRIG;						// To diagnose rising edge of separated box
	rtrigSelectedM				: R_TRIG;						// To diagnose rising edge of selected metal box
	rtrigSelectedP				: R_TRIG;						// To diagnose rising edge of selected plastic box
	iBoxesOnTheWay				: INT;							// Number of boxes being moved
	lrClampTemps				: ARRAY[1..100] OF LREAL;		// Temperature of clamp cylinder
	lrBarrierTemps				: ARRAY[1..100] OF LREAL;		// Temperature of barrier cylinder
	lrMetalTemps				: ARRAY[1..100] OF LREAL;		// Temperature of metal cylinder
	lrPlasticTemps				: ARRAY[1..100] OF LREAL;		// Temperature of plastic cylinder
	bStartingStart				: BOOL;							// True if state machine is in state STARTING
	bResetStart					: BOOL;							// True if state machine is in state RESETTING
	bHaltStart					: BOOL;							// True if state machine is in state STOPPING
	iHaltTriesSeperate			: INT;
	iHaltTriesMetal				: INT;
	iHaltTriesPlastic			: INT;
END_VAR

// =========================================================
	// Getting errors of modules
	
bError := fbSeparateModule.fbAxis.iErrorID <> 0
			OR fbMetalSorting.fbAxis.iErrorID <> 0
			OR fbPlasticSorting.fbAxis.iErrorID <> 0
			OR fbSeparateModule.bClampError OR fbSeparateModule.bBarrierError
			OR fbMetalSorting.bCylError OR fbPlasticSorting.bCylError;
	
// =========================================================
	// Setting velocities of axes

IF ePMLUnitMode = ePMLUnitMode_AUTOMATIC OR ePMLUnitMode = ePMLUnitMode_SEMIAUTOMATIC THEN
	lrAxisVelo := 100;
ELSE
	lrAxisVelo := 50;
END_IF

// =========================================================
	// Noticing separated and selected boxes
	
rtrigSeparated( CLK := fbSeparateModule.bSeparated );
rtrigSelectedM( CLK := fbMetalSorting.bSelected );
rtrigSelectedP( CLK := fbPlasticSorting.bSelected );
						
// =========================================================
	// Getting cylinder temperatures of modules
	
lrBarrierTemps := fbSeparateModule.lrBarrierTemps;
lrClampTemps := fbSeparateModule.lrClampTemps;
lrMetalTemps := fbMetalSorting.lrTemps;
lrPlasticTemps := fbPlasticSorting.lrTemps;

// =========================================================
	// Cylinder options of modules
	
fbSeparateModule.M_CylinderOptions();
fbMetalSorting.M_CylinderOptions();
fbPlasticSorting.M_CylinderOptions();

// =========================================================
	// Mode and state requests
A_Requests();

	// Enable for power supply, compressed air control and buttons
A_Enable();

	// Input variables of separating and sorting modules
A_ModuleInputs();

	// Output variables
A_SetOutput();

	// State machine
A_StateMachine();

	// Visualization
A_Visu();

// =========================================================

ACTION A_Automatic:
// =========================================================

CASE ePMLState OF
	
// =========================================================
// Turning axis reset off, passing it to axis instances
	ePMLState_IDLE:		IF bResetStart THEN
							bResetStart := FALSE;
							fbSeparateModule.bReset := FALSE;
							fbSeparateModule.M_Reset();
							fbMetalSorting.bReset := FALSE;
							fbMetalSorting.M_Reset();
							fbPlasticSorting.bReset := FALSE;
							fbPlasticSorting.M_Reset();
							fbStateMachineAuto.StateComplete := FALSE;	
						END_IF
	
// =========================================================
// Resetting variables for executing automatic mode, checking status of axes
	ePMLState_STARTING:	IF NOT bStartingStart THEN
							bStartingStart := TRUE;
							fbSeparateModule.bStarting := TRUE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := TRUE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := TRUE;
							fbPlasticSorting.M_Starting();
						END_IF

						IF NOT fbSeparateModule.bStartingDone THEN
							fbSeparateModule.M_Starting();
						END_IF
						IF NOT fbMetalSorting.bStartingDone THEN
							fbMetalSorting.M_Starting();
						END_IF
						IF NOT fbPlasticSorting.bStartingDone THEN
							fbPlasticSorting.M_Starting();
						END_IF

						IF fbSeparateModule.bStartingDone AND fbMetalSorting.bStartingDone
							AND fbPlasticSorting.bStartingDone THEN
								fbStateMachineAuto.StateComplete := TRUE;
						END_IF

// =========================================================
// Executing automatic mode
	ePMLState_EXECUTE:	IF bStartingStart THEN
							bStartingStart := FALSE;
							fbSeparateModule.bStarting := FALSE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := FALSE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := FALSE;
							fbPlasticSorting.M_Starting();
							fbStateMachineAuto.StateComplete := FALSE;
						END_IF
						
						fbSeparateModule.M_Automatic();
						fbMetalSorting.M_Automatic();
						fbPlasticSorting.M_Automatic();
						
						IF rtrigSeparated.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay + 1;
						END_IF
						IF rtrigSelectedM.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						IF rtrigSelectedP.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						
// =========================================================
// Stopping axes
	ePMLState_ABORTING:	IF NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();						
						END_IF

						IF NOT fbSeparateModule.bHaltDone THEN
							fbSeparateModule.M_Stop();
						END_IF
						IF NOT fbMetalSorting.bHaltDone THEN
							fbMetalSorting.M_Stop();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone THEN
							fbPlasticSorting.M_Stop();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone THEN
								fbStateMachineAuto.StateComplete := TRUE;
						END_IF
	
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_ABORTED:	IF fbStateMachineAuto.StateComplete THEN
							fbStateMachineAuto.StateComplete := FALSE;
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF
	
// =========================================================
	ePMLState_CLEARING:	fbStateMachineAuto.StateComplete := TRUE;
	
// =========================================================
// Selecting boxes on conveyor belt to destination, then stopping axes
	ePMLState_STOPPING:	IF rtrigSeparated.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay + 1;
						END_IF
						IF rtrigSelectedM.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						IF rtrigSelectedP.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						
						IF iBoxesOnTheWay = 0 AND NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();;
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();			
						END_IF
						
						IF NOT fbSeparateModule.bHaltDone OR iBoxesOnTheWay <> 0 THEN
							fbSeparateModule.M_Automatic();
						END_IF
						IF NOT fbMetalSorting.bHaltDone OR iBoxesOnTheWay <> 0 THEN
							fbMetalSorting.M_Automatic();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone OR iBoxesOnTheWay <> 0 THEN
							fbPlasticSorting.M_Automatic();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone AND iBoxesOnTheWay = 0 THEN
								fbStateMachineAuto.StateComplete := TRUE;
						END_IF
					
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_STOPPED:	IF fbStateMachineAuto.StateComplete THEN
							fbStateMachineAuto.StateComplete := FALSE;	
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF

// =========================================================
// Resetting cylinders and axes
	ePMLState_RESETTING:	IF NOT bResetStart THEN
								bResetStart := TRUE;
								fbSeparateModule.bReset := TRUE;
								fbSeparateModule.M_Reset();
								fbMetalSorting.bReset := TRUE;
								fbMetalSorting.M_Reset();
								fbPlasticSorting.bReset := TRUE;
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF NOT fbSeparateModule.bResetDone THEN
								fbSeparateModule.M_Reset();
							END_IF
							IF NOT fbMetalSorting.bResetDone THEN
								fbMetalSorting.M_Reset();
							END_IF
							IF NOT fbPlasticSorting.bResetDone THEN
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF fbSeparateModule.bResetDone AND fbMetalSorting.bResetDone AND fbPlasticSorting.bResetDone 
								AND fbSeparateModule.bClampAtBase AND fbSeparateModule.bBarrierAtBase
								AND fbMetalSorting.bAtBase AND fbPlasticSorting.bAtBase THEN
									iBoxesOnTheWay := 0;
									fbStateMachineAuto.StateComplete := TRUE;
							END_IF
END_CASE

// =========================================================
END_ACTION

ACTION A_Enable:
// =========================================================
		// Power supply

fbButtonPower.bEnable := TRUE;
fbPowerSupply.bInput := fbButtonPower.bOut;
fbPowerSupply.bEnable := TRUE;

// =========================================================
		// Enable of axes

IF ePMLState = ePMLState_ABORTED THEN
	fbSeparateModule.bAxisEnable := FALSE;
	fbMetalSorting.bAxisEnable := FALSE;
	fbPlasticSorting.bAxisEnable := FALSE;
ELSIF fbPowerSupply.bOut THEN
	fbSeparateModule.bAxisEnable := TRUE;
	fbMetalSorting.bAxisEnable := TRUE;
	fbPlasticSorting.bAxisEnable := TRUE;
END_IF

// =========================================================
		// Manual axis control
		
bManualAxisEnable := fbPowerSupply.bOut AND (ePMLState = ePMLState_EXECUTE)
					AND ((ePMLUnitMode = ePMLUnitMode_MANUAL) OR (ePMLUnitMode = ePMLUnitMode_MAINTENANCE));
					
fbSeparateModule.bManualAxisEnable := bManualAxisEnable;
fbMetalSorting.bManualAxisEnable := bManualAxisEnable;
fbPlasticSorting.bManualAxisEnable := bManualAxisEnable;

// =========================================================
		// Compressed air control
	
IF ePMLUnitMode <> ePMLUnitMode_MAINTENANCE THEN
	fbComprAir.bInput := fbPowerSupply.bOut;
ELSE
	fbComprAir.bInput := fbButtonComprAir.bOut;
END_IF

fbComprAir.bEnable := TRUE;
fbButtonComprAir.bEnable := ePMLUnitMode = ePMLUnitMode_MAINTENANCE;

// =========================================================
		// Enable of sensors
		
fbSeparateModule.bSensorEnable := TRUE;
fbMetalSorting.bSensorEnable := TRUE;
fbPlasticSorting.bSensorEnable := TRUE;

// =========================================================
		// Enable actions of modules

fbSeparateModule.M_Enable();
fbMetalSorting.M_Enable();
fbPlasticSorting.M_Enable();

// =========================================================
		// States and modes
		
	// Start button
fbButtonStart.bEnable := NOT (ePMLState = ePMLState_IDLE AND bError);
	// Stop button
fbButtonStop.bEnable := ePMLState = ePMLState_STOPPING OR ePMLState = ePMLState_EXECUTE OR ePMLState = ePMLState_IDLE;
	// Reset button
fbButtonReset.bEnable := (ePMLState = ePMLState_STOPPED);
	// Abort button
fbButtonAbort.bInput := NOT fbPowerSupply.bOut;
fbButtonAbort.bEnable := (ePMLState = ePMLState_EXECUTE OR ePMLState = ePMLState_STOPPING
							OR ePMLState = ePMLState_RESETTING);
	// Automatic mode button
fbButtonAuto.bEnable := ePMLUnitMode <> ePMLUnitMode_AUTOMATIC AND ePMLState = ePMLState_IDLE;
	// Semi-automatic mode button *)
fbButtonSemi.bEnable := ePMLUnitMode <> ePMLUnitMode_SEMIAUTOMATIC AND ePMLState = ePMLState_IDLE;
	// Manual mode button
fbButtonManual.bEnable := ePMLUnitMode <> ePMLUnitMode_MANUAL AND ePMLState = ePMLState_IDLE;
	// Maintenance mode button
fbButtonMaintenance.bEnable := ePMLUnitMode <> ePMLUnitMode_MAINTENANCE AND ePMLState = ePMLState_IDLE;

// =========================================================
END_ACTION

ACTION A_Maintenance:
// =========================================================

CASE ePMLState OF
	
// =========================================================
// Turning axis reset off, passing it to axis instances
	ePMLState_IDLE:		IF bResetStart THEN
							bResetStart := FALSE;
							fbSeparateModule.bReset := FALSE;
							fbSeparateModule.M_Reset();
							fbMetalSorting.bReset := FALSE;
							fbMetalSorting.M_Reset();
							fbPlasticSorting.bReset := FALSE;
							fbPlasticSorting.M_Reset();
							fbStateMachineMaintenance.StateComplete := FALSE;
						END_IF
	
// =========================================================
// Checking status of axes
	ePMLState_STARTING:	IF NOT bStartingStart THEN
							bStartingStart := TRUE;
							fbSeparateModule.bStarting := TRUE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := TRUE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := TRUE;
							fbPlasticSorting.M_Starting();
						END_IF

						IF NOT fbSeparateModule.bStartingDone THEN
							fbSeparateModule.M_Starting();
						END_IF
						IF NOT fbMetalSorting.bStartingDone THEN
							fbMetalSorting.M_Starting();
						END_IF
						IF NOT fbPlasticSorting.bStartingDone THEN
							fbPlasticSorting.M_Starting();
						END_IF

						IF fbSeparateModule.bStartingDone AND fbMetalSorting.bStartingDone
							AND fbPlasticSorting.bStartingDone THEN
								fbStateMachineMaintenance.StateComplete := TRUE;
						END_IF

// =========================================================
// Executing maintenance mode
	ePMLState_EXECUTE:	IF bStartingStart THEN
							bStartingStart := FALSE;
							fbSeparateModule.bStarting := FALSE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := FALSE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := FALSE;
							fbPlasticSorting.M_Starting();
							fbStateMachineMaintenance.StateComplete := FALSE;
						END_IF
						
						fbSeparateModule.M_Maintenance();
						fbMetalSorting.M_Maintenance();
						fbPlasticSorting.M_Maintenance();
						
// =========================================================
// Stopping axes
	ePMLState_ABORTING:	IF NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();						
						END_IF

						IF NOT fbSeparateModule.bHaltDone THEN
							fbSeparateModule.M_Stop();
						END_IF
						IF NOT fbMetalSorting.bHaltDone THEN
							fbMetalSorting.M_Stop();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone THEN
							fbPlasticSorting.M_Stop();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone THEN
								fbStateMachineMaintenance.StateComplete := TRUE;
						END_IF
	
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_ABORTED:	IF fbStateMachineMaintenance.StateComplete THEN
							fbStateMachineMaintenance.StateComplete := FALSE;
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF
	
// =========================================================
	ePMLState_CLEARING:	fbStateMachineMaintenance.StateComplete := TRUE;
	
// =========================================================
// Stopping axes
	ePMLState_STOPPING:	IF NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();					
						END_IF

						IF NOT fbSeparateModule.bHaltDone THEN
							fbSeparateModule.M_Stop();
						END_IF
						IF NOT fbMetalSorting.bHaltDone THEN
							fbMetalSorting.M_Stop();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone THEN
							fbPlasticSorting.M_Stop();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone THEN
								fbStateMachineMaintenance.StateComplete := TRUE;
						END_IF
					
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_STOPPED:	IF fbStateMachineMaintenance.StateComplete THEN
							fbStateMachineMaintenance.StateComplete := FALSE;
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF

// =========================================================
// Resetting cylinders and axes
	ePMLState_RESETTING:	IF NOT bResetStart THEN
								bResetStart := TRUE;
								fbSeparateModule.bReset := TRUE;
								fbSeparateModule.M_Reset();
								fbMetalSorting.bReset := TRUE;
								fbMetalSorting.M_Reset();
								fbPlasticSorting.bReset := TRUE;
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF NOT fbSeparateModule.bResetDone THEN
								fbSeparateModule.M_Reset();
							END_IF
							IF NOT fbMetalSorting.bResetDone THEN
								fbMetalSorting.M_Reset();
							END_IF
							IF NOT fbPlasticSorting.bResetDone THEN
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF fbSeparateModule.bResetDone AND fbMetalSorting.bResetDone AND fbPlasticSorting.bResetDone 
								AND fbSeparateModule.bClampAtBase AND fbSeparateModule.bBarrierAtBase
								AND fbMetalSorting.bAtBase AND fbPlasticSorting.bAtBase THEN
									fbStateMachineMaintenance.StateComplete := TRUE;
							END_IF
END_CASE

// =========================================================
END_ACTION

ACTION A_Manual:
// =========================================================

CASE ePMLState OF
	
// =========================================================
// Turning axis reset off, passing it to axis instances
	ePMLState_IDLE:		IF bResetStart THEN
							bResetStart := FALSE;
							fbSeparateModule.bReset := FALSE;
							fbSeparateModule.M_Reset();
							fbMetalSorting.bReset := FALSE;
							fbMetalSorting.M_Reset();
							fbPlasticSorting.bReset := FALSE;
							fbPlasticSorting.M_Reset();
							fbStateMachineManual.StateComplete := FALSE;
						END_IF
	
// =========================================================
// Checking status of axes
	ePMLState_STARTING:	IF NOT bStartingStart THEN
							bStartingStart := TRUE;
							fbSeparateModule.bStarting := TRUE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := TRUE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := TRUE;
							fbPlasticSorting.M_Starting();
						END_IF

						IF NOT fbSeparateModule.bStartingDone THEN
							fbSeparateModule.M_Starting();
						END_IF
						IF NOT fbMetalSorting.bStartingDone THEN
							fbMetalSorting.M_Starting();
						END_IF
						IF NOT fbPlasticSorting.bStartingDone THEN
							fbPlasticSorting.M_Starting();
						END_IF

						IF fbSeparateModule.bStartingDone AND fbMetalSorting.bStartingDone
							AND fbPlasticSorting.bStartingDone THEN
								fbStateMachineManual.StateComplete := TRUE;
						END_IF

// =========================================================
// Executing manual mode
	ePMLState_EXECUTE:	IF bStartingStart THEN
							bStartingStart := FALSE;
							fbSeparateModule.bStarting := FALSE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := FALSE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := FALSE;
							fbPlasticSorting.M_Starting();
							fbStateMachineManual.StateComplete := FALSE;
						END_IF
						
						fbSeparateModule.M_Manual();
						fbMetalSorting.M_Manual();
						fbPlasticSorting.M_Manual();
						
// =========================================================
// Stopping axes
	ePMLState_ABORTING:	IF NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();						
						END_IF

						IF NOT fbSeparateModule.bHaltDone THEN
							fbSeparateModule.M_Stop();
						END_IF
						IF NOT fbMetalSorting.bHaltDone THEN
							fbMetalSorting.M_Stop();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone THEN
							fbPlasticSorting.M_Stop();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone THEN
								fbStateMachineManual.StateComplete := TRUE;
						END_IF
	
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_ABORTED:	IF fbStateMachineManual.StateComplete THEN
							fbStateMachineManual.StateComplete := FALSE;
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF
	
// =========================================================
	ePMLState_CLEARING:	fbStateMachineManual.StateComplete := TRUE;
	
// =========================================================
// Stopping axes
	ePMLState_STOPPING:	IF NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();					
						END_IF

						IF NOT fbSeparateModule.bHaltDone THEN
							fbSeparateModule.M_Stop();
						END_IF
						IF NOT fbMetalSorting.bHaltDone THEN
							fbMetalSorting.M_Stop();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone THEN
							fbPlasticSorting.M_Stop();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone THEN
								fbStateMachineManual.StateComplete := TRUE;
						END_IF
					
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_STOPPED:	IF fbStateMachineManual.StateComplete THEN
							fbStateMachineManual.StateComplete := FALSE;
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF

// =========================================================
// Resetting cylinders and axes
	ePMLState_RESETTING:	IF NOT bResetStart THEN
								bResetStart := TRUE;
								fbSeparateModule.bReset := TRUE;
								fbSeparateModule.M_Reset();
								fbMetalSorting.bReset := TRUE;
								fbMetalSorting.M_Reset();
								fbPlasticSorting.bReset := TRUE;
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF NOT fbSeparateModule.bResetDone THEN
								fbSeparateModule.M_Reset();
							END_IF
							IF NOT fbMetalSorting.bResetDone THEN
								fbMetalSorting.M_Reset();
							END_IF
							IF NOT fbPlasticSorting.bResetDone THEN
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF fbSeparateModule.bResetDone AND fbMetalSorting.bResetDone AND fbPlasticSorting.bResetDone 
								AND fbSeparateModule.bClampAtBase AND fbSeparateModule.bBarrierAtBase
								AND fbMetalSorting.bAtBase AND fbPlasticSorting.bAtBase THEN
									fbStateMachineManual.StateComplete := TRUE;
							END_IF
END_CASE

// =========================================================
END_ACTION

ACTION A_ModuleInputs:
// =========================================================
		// Separating modul

	// Compressed air, state and button signals
fbSeparateModule.bComprAirEnabled := fbComprAir.bOut;
fbSeparateModule.bExecute := ePMLState = ePMLState_EXECUTE;
fbSeparateModule.bSemiStart := rtrigStart.Q;

	// Choose desired clamp cylinder
fbSeparateModule.bClampDiag := TRUE;
fbSeparateModule.bClampTemp := TRUE;
fbSeparateModule.bClampRecord := FALSE;

	// Choose desired barrier cylinder
fbSeparateModule.bBarrierDiag := FALSE;
fbSeparateModule.bBarrierTemp := TRUE;
fbSeparateModule.bBarrierRecord := TRUE;

	// Axis velocity
fbSeparateModule.lrAxisVelo := lrAxisVelo;

	// Timer values for clamp cylinder
fbSeparateModule.tiTimeOutClamp := T#2.5S;
fbSeparateModule.tiRecordIntervallClamp := T#1S;

	// Timer values for barrier cylinder
fbSeparateModule.tiTimeOutBarrier := T#3S;
fbSeparateModule.tiRecordIntervallBarrier := T#1S;

	// Timer value for separating process
fbSeparateModule.tiBarrierAtWork := T#4.5S;

	// Information about number of boxes being sorted
fbSeparateModule.iBoxesOnTheWay := iBoxesOnTheWay;

// =========================================================
		// Sorting modul for metal boxes

	// Compressed air signal
fbMetalSorting.bComprAirEnabled := fbComprAir.bOut;
	
	// Choose desired cylinder
fbMetalSorting.bCylinderDiag := TRUE;
fbMetalSorting.bCylinderTemp := FALSE;
fbMetalSorting.bCylinderRecord := FALSE;

	// Axis velocity
fbMetalSorting.lrAxisVelo := lrAxisVelo;

	// Timer values
fbMetalSorting.tiTimeOutCylinder := T#3S;
fbMetalSorting.tiRecordIntervall := T#1S;
fbMetalSorting.tiMoveAxis := T#2.5S;
fbMetalSorting.tiSensorDelay := T#3S;

// =========================================================
		// Sorting modul for plastic boxes

	// Compressed air signal
fbPlasticSorting.bComprAirEnabled := fbComprAir.bOut;
	
	// Choose desired cylinder
fbPlasticSorting.bCylinderDiag := TRUE;
fbPlasticSorting.bCylinderTemp := FALSE;
fbPlasticSorting.bCylinderRecord := FALSE;

	// Axis velocity
fbPlasticSorting.lrAxisVelo := lrAxisVelo;

	// Timer values
fbPlasticSorting.tiTimeOutCylinder := T#3S;
fbPlasticSorting.tiRecordIntervall := T#1S;
fbPlasticSorting.tiMoveAxis := T#2.5S;
fbPlasticSorting.tiSensorDelay := T#3S;

// =========================================================
END_ACTION

ACTION A_Requests:
// =========================================================
	// Check for state requests

rtrigStart( CLK := fbButtonStart.bOut);

IF bStartButtonOff AND NOT fbButtonStart.bInput THEN
	bStartButtonOff := FALSE;
END_IF

IF rtrigStart.Q THEN
	bStartButtonOff := TRUE;

	IF ePMLState = ePMLState_ABORTED THEN
		ePMLStateRequested := ePMLState_CLEARING;
	ELSIF ePMLState = ePMLState_STOPPED THEN
		ePMLStateRequested := ePMLState_RESETTING;
	ELSIF ePMLState = ePMLState_IDLE AND fbPowerSupply.bOut THEN
		ePMLStateRequested := ePMLState_STARTING;
	END_IF
	
ELSIF fbButtonStop.bOut THEN
	ePMLStateRequested := ePMLState_STOPPING;
ELSIF fbButtonReset.bOut THEN
	ePMLStateRequested := ePMLState_RESETTING;
END_IF

// =========================================================
	// Check for mode requests

IF fbButtonManual.bOut THEN
	ePMLUnitModeRequested := ePMLUnitMode_MANUAL;
ELSIF fbButtonAuto.bOut THEN
	ePMLUnitModeRequested := ePMLUnitMode_AUTOMATIC;
ELSIF fbButtonSemi.bOut THEN
	ePMLUnitModeRequested := ePMLUnitMode_SEMIAUTOMATIC;
ELSIF fbButtonMaintenance.bOut THEN
	ePMLUnitModeRequested := ePMLUnitMode_MAINTENANCE;
END_IF

IF fbButtonManual.bOut OR fbButtonAuto.bOut OR fbButtonSemi.bOut OR fbButtonMaintenance.bOut THEN
	fbUnitModeManager(Execute := TRUE,
					eModeCommand := ePMLUnitModeRequested,
					ePMLState := ePMLState);
END_IF

IF fbUnitModeManager.Done THEN
	ePMLUnitMode := fbUnitModeManager.eModeStatus;
	fbUnitModeManager(Execute := FALSE);
END_IF
// =========================================================
END_ACTION

ACTION A_Semiautomatic:
// =========================================================

CASE ePMLState OF
	
// =========================================================
// Turning axis reset off, passing it to axis instances
	ePMLState_IDLE:		IF bResetStart THEN
							bResetStart := FALSE;
							fbSeparateModule.bReset := FALSE;
							fbSeparateModule.M_Reset();
							fbMetalSorting.bReset := FALSE;
							fbMetalSorting.M_Reset();
							fbPlasticSorting.bReset := FALSE;
							fbPlasticSorting.M_Reset();
							fbStateMachineSemiAuto.StateComplete := FALSE;
						END_IF
	
// =========================================================
// Resetting variables for executing automatic mode, checking status of axes
	ePMLState_STARTING:	IF NOT bStartingStart THEN
							bStartingStart := TRUE;
							fbSeparateModule.bStarting := TRUE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := TRUE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := TRUE;
							fbPlasticSorting.M_Starting();
						END_IF

						IF NOT fbSeparateModule.bStartingDone THEN
							fbSeparateModule.M_Starting();
						END_IF
						IF NOT fbMetalSorting.bStartingDone THEN
							fbMetalSorting.M_Starting();
						END_IF
						IF NOT fbPlasticSorting.bStartingDone THEN
							fbPlasticSorting.M_Starting();
						END_IF

						IF fbSeparateModule.bStartingDone AND fbMetalSorting.bStartingDone
							AND fbPlasticSorting.bStartingDone THEN
								fbStateMachineSemiAuto.StateComplete := TRUE;
						END_IF

// =========================================================
// Executing semi-automatic mode
	ePMLState_EXECUTE:	IF bStartingStart THEN
							bStartingStart := FALSE;
							fbSeparateModule.bStarting := FALSE;
							fbSeparateModule.M_Starting();
							fbMetalSorting.bStarting := FALSE;
							fbMetalSorting.M_Starting();
							fbPlasticSorting.bStarting := FALSE;
							fbPlasticSorting.M_Starting();
							fbStateMachineSemiAuto.StateComplete := FALSE;
						END_IF
						
						fbSeparateModule.M_Semiautomatic();
						fbMetalSorting.M_Semiautomatic();
						fbPlasticSorting.M_Semiautomatic();
						
						IF rtrigSeparated.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay + 1;
						END_IF
						IF rtrigSelectedM.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						IF rtrigSelectedP.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						
// =========================================================
// Stopping axes
	ePMLState_ABORTING:	IF NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();						
						END_IF

						IF NOT fbSeparateModule.bHaltDone THEN
							fbSeparateModule.M_Stop();
						END_IF
						IF NOT fbMetalSorting.bHaltDone THEN
							fbMetalSorting.M_Stop();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone THEN
							fbPlasticSorting.M_Stop();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone THEN
								fbStateMachineSemiAuto.StateComplete := TRUE;
						END_IF
	
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_ABORTED:	IF fbStateMachineSemiAuto.StateComplete THEN
							fbStateMachineSemiAuto.StateComplete := FALSE;
						END_IF
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF
	
// =========================================================
	ePMLState_CLEARING:	fbStateMachineSemiAuto.StateComplete := TRUE;
	
// =========================================================
// Selecting boxes on conveyor belt to destination, then stopping axes
	ePMLState_STOPPING:	IF rtrigSeparated.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay + 1;
						END_IF
						IF rtrigSelectedM.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						IF rtrigSelectedP.Q THEN
							iBoxesOnTheWay := iBoxesOnTheWay - 1;
						END_IF
						
						IF iBoxesOnTheWay = 0 AND NOT bHaltStart THEN
							bHaltStart := TRUE;
							fbSeparateModule.bHalt := TRUE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := TRUE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := TRUE;
							fbPlasticSorting.M_Stop();						
						END_IF
						
						IF NOT fbSeparateModule.bHaltDone OR iBoxesOnTheWay <> 0 THEN
							fbSeparateModule.M_Automatic();
						END_IF
						IF NOT fbMetalSorting.bHaltDone OR iBoxesOnTheWay <> 0 THEN
							fbMetalSorting.M_Automatic();
						END_IF
						IF NOT fbPlasticSorting.bHaltDone OR iBoxesOnTheWay <> 0 THEN
							fbPlasticSorting.M_Automatic();
						END_IF

						IF fbSeparateModule.bHaltDone AND fbMetalSorting.bHaltDone
							AND fbPlasticSorting.bHaltDone AND iBoxesOnTheWay = 0 THEN
								fbStateMachineSemiAuto.StateComplete := TRUE;
						END_IF
					
// =========================================================
// Turning off axis stop, passing it to axis instances
	ePMLState_STOPPED:	IF fbStateMachineSemiAuto.StateComplete THEN
							fbStateMachineSemiAuto.StateComplete := FALSE;
						END_IF
						
						IF bHaltStart THEN
							bHaltStart := FALSE;
							fbSeparateModule.bHalt := FALSE;
							fbSeparateModule.M_Stop();
							fbMetalSorting.bHalt := FALSE;
							fbMetalSorting.M_Stop();
							fbPlasticSorting.bHalt := FALSE;
							fbPlasticSorting.M_Stop();
						END_IF

// =========================================================
// Resetting cylinders and axes
	ePMLState_RESETTING:	IF NOT bResetStart THEN
								bResetStart := TRUE;
								fbSeparateModule.bReset := TRUE;
								fbSeparateModule.M_Reset();
								fbMetalSorting.bReset := TRUE;
								fbMetalSorting.M_Reset();
								fbPlasticSorting.bReset := TRUE;
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF NOT fbSeparateModule.bResetDone THEN
								fbSeparateModule.M_Reset();
							END_IF
							IF NOT fbMetalSorting.bResetDone THEN
								fbMetalSorting.M_Reset();
							END_IF
							IF NOT fbPlasticSorting.bResetDone THEN
								fbPlasticSorting.M_Reset();
							END_IF
							
							IF fbSeparateModule.bResetDone AND fbMetalSorting.bResetDone AND fbPlasticSorting.bResetDone 
								AND fbSeparateModule.bClampAtBase AND fbSeparateModule.bBarrierAtBase
								AND fbMetalSorting.bAtBase AND fbPlasticSorting.bAtBase THEN
									iBoxesOnTheWay := 0;
									fbStateMachineSemiAuto.StateComplete := TRUE;
							END_IF
END_CASE

// =========================================================
END_ACTION

ACTION A_SetOutput:
// =========================================================
		// State variables

bStopped := (ePMLState = ePMLState_STOPPED);
bStarted := (ePMLState = ePMLState_EXECUTE);
bReset := (ePMLState = ePMLState_RESETTING);
bAborted := (ePMLState = ePMLState_ABORTED);
bIdle := (ePMLState = ePMLState_IDLE AND fbPowerSupply.bOut);

// =========================================================
		// Mode variables

bAuto := (ePMLUnitMode = ePMLUnitMode_AUTOMATIC);
bSemi := (ePMLUnitMode = ePMLUnitMode_SEMIAUTOMATIC);
bManual := (ePMLUnitMode = ePMLUnitMode_MANUAL);
bMaintenance := (ePMLUnitMode = ePMLUnitMode_MAINTENANCE);

// =========================================================
		// Power supply and compressed air control
		
fbPowerSupply.M_SetOutput();
fbComprAir.M_SetOutput();		

// =========================================================
		// Modules

fbSeparateModule.M_SetOutput();
fbMetalSorting.M_SetOutput();
fbPlasticSorting.M_SetOutput();

// =========================================================
		// Buttons

	// Power supply and compressed air control
fbButtonPower.M_SetOutput();
fbButtonComprAir.M_SetOutput();	

	// States
fbButtonStart.M_SetOutput();
fbButtonStop.M_SetOutput();
fbButtonReset.M_SetOutput();
fbButtonAbort.M_SetOutput();

	// Modes
fbButtonAuto.M_SetOutput();
fbButtonSemi.M_SetOutput();
fbButtonManual.M_SetOutput();
fbButtonMaintenance.M_SetOutput();	
	
// =========================================================
END_ACTION

ACTION A_StateMachine:
// =========================================================
	// Mode and state handling
	
CASE ePMLUnitMode OF
	ePMLUnitMode_AUTOMATIC:		fbStateMachineAuto(Start := ePMLStateRequested = ePMLState_STARTING,
												 Stop := fbButtonStop.bOut,
												 Reset := fbButtonReset.bOut OR ePMLStateRequested = ePMLState_RESETTING,
												 Clear := ePMLStateRequested = ePMLState_CLEARING,
												 Abort := fbButtonAbort.bOut OR (bError AND ePMLState = ePMLState_EXECUTE),
												 Machine := refMachine);
								ePMLState := fbStateMachineAuto.ePMLState;
								A_Automatic();

// =========================================================	
	ePMLUnitMode_MANUAL:		fbStateMachineManual(Start := ePMLStateRequested = ePMLState_STARTING,
													 Stop := fbButtonStop.bOut,
													 Reset := fbButtonReset.bOut OR ePMLStateRequested = ePMLState_RESETTING,
													 Clear := ePMLStateRequested = ePMLState_CLEARING,
													 Abort := fbButtonAbort.bOut OR (bError AND ePMLState = ePMLState_EXECUTE),
													 Machine := refMachine);
								ePMLState := fbStateMachineManual.ePMLState;
								A_Manual();
	
// =========================================================						
	ePMLUnitMode_SEMIAUTOMATIC:	fbStateMachineSemiAuto(Start := ePMLStateRequested = ePMLState_STARTING,
													 Stop := fbButtonStop.bOut,
													 Reset := fbButtonReset.bOut OR ePMLStateRequested = ePMLState_RESETTING,
													 Clear := ePMLStateRequested = ePMLState_CLEARING,
													 Abort := fbButtonAbort.bOut OR (bError AND ePMLState = ePMLState_EXECUTE),
													 Machine := refMachine);
								ePMLState := fbStateMachineSemiAuto.ePMLState;
								A_Semiautomatic();
	
// =========================================================						
	ePMLUnitMode_MAINTENANCE:	fbStateMachineMaintenance(Start := ePMLStateRequested = ePMLState_STARTING,
													 Stop := fbButtonStop.bOut,
													 Reset := fbButtonReset.bOut OR ePMLStateRequested = ePMLState_RESETTING,
													 Clear := ePMLStateRequested = ePMLState_CLEARING,
													 Abort := fbButtonAbort.bOut OR (bError AND ePMLState = ePMLState_EXECUTE),
													 Machine := refMachine);
								ePMLState := fbStateMachineMaintenance.ePMLState;
								A_Maintenance();
END_CASE

// =========================================================
END_ACTION

ACTION A_Visu:
// =========================================================
		// Calling visu function block
		
fbVisu(	bError  				:= bError, 
		lrAxisVelo 				:= lrAxisVelo, 
		bComprAirEnabled 		:= fbComprAir.bOut, 
		bPowerEnabled 			:= fbPowerSupply.bOut, 
		bMainAxisMoves 			:= fbSeparateModule.bAxisMoves, 
		bMetalAxisMoves 		:= fbMetalSorting.bAxisMoves, 
		bPlasticAxisMoves 		:= fbPlasticSorting.bAxisMoves, 
		bClampToWork 			:= fbSeparateModule.bClampToWork, 
		bBarrierToWork 			:= fbSeparateModule.bBarrierToWork, 
		bMetalToWork 			:= fbMetalSorting.bToWork, 
		bPlasticToWork 			:= fbPlasticSorting.bToWork, 
		bClampError 			:= fbSeparateModule.bClampError, 
		sClampErrMsg 			:= fbSeparateModule.sClampErrorMsg, 
		bMetalCylError 			:= fbMetalSorting.bCylError, 
		sMetalErrMsg 			:= fbMetalSorting.sCylErrorMsg, 
		bPlasticCylError 		:= fbPlasticSorting.bCylError, 
		sPlasticErrMsg 			:= fbPlasticSorting.sCylErrorMsg, 
		iMainAxisErrorId 		:= fbSeparateModule.fbAxis.iErrorID, 
		iMetalAxisErrorId 		:= fbMetalSorting.fbAxis.iErrorID, 
		iPlasticAxisErrorId		:= fbPlasticSorting.fbAxis.iErrorID, 
		bStarted 				:= bStarted, 
		bStopped 				:= bStopped, 
		bReset 					:= bReset, 
		bAborted 				:= bAborted, 
		bIdle					:= bIdle, 
		bAuto 					:= bAuto, 
		bSemi 					:= bSemi, 
		bManual 				:= bManual, 
		bMaintenance 			:= bMaintenance, 
		bStartButtonOff 		:= bStartButtonOff, 
		bButtonPowerIn 			:= fbButtonPower.bOut, 
		bButtonComprAirIn 		:= fbButtonComprAir.bOut, 
		bButtonStartIn 			:= fbButtonStart.bOut, 
		bButtonStopIn 			:= fbButtonStop.bOut, 
		bButtonResetIn 			:= fbButtonReset.bOut, 
		bButtonAbortIn 			:= fbButtonAbort.bOut, 
		bButtonAutoIn 			:= fbButtonAuto.bOut, 
		bButtonSemiIn 			:= fbButtonSemi.bOut, 
		bButtonManuIn 			:= fbButtonManual.bOut, 
		bButtonMaintenanceIn 	:= fbButtonMaintenance.bOut, 
		bButtonMainFwIn 		:= fbSeparateModule.bButtonAxisFwOut,
		bButtonMainBwIn 		:= fbSeparateModule.bButtonAxisBwOut, 
		bButtonMetalFwIn 		:= fbMetalSorting.bButtonAxisFwOut, 
		bButtonMetalBwIn 		:= fbMetalSorting.bButtonAxisBwOut, 
		bButtonPlasticFwIn 		:= fbPlasticSorting.bButtonAxisFwOut, 
		bButtonPlasticBwIn 		:= fbPlasticSorting.bButtonAxisBwOut, 
		bButtonClampToWorkIn 	:= fbSeparateModule.bButtonClampToWorkOut, 
		bButtonBarrierToWorkIn 	:= fbSeparateModule.bButtonBarrierToWorkOut, 
		bButtonMetalToWorkIn 	:= fbMetalSorting.bButtonCylToWorkOut, 
		bButtonPlasticToWorkIn 	:= fbPlasticSorting.bButtonCylToWorkOut, 
		
		bButtonPowerOut			=> fbButtonPower.bInput, 
		bButtonComprAirOut 		=> fbButtonComprAir.bInput, 
		bButtonStartOut 		=> fbButtonStart.bInput, 
		bButtonStopOut 			=> fbButtonStop.bInput, 
		bButtonResetOut 		=> fbButtonReset.bInput, 
		bButtonAutoOut 			=> fbButtonAuto.bInput, 
		bButtonSemiOut 			=> fbButtonSemi.bInput, 
		bButtonManuOut 			=> fbButtonManual.bInput, 
		bButtonMaintenanceOut 	=> fbButtonMaintenance.bInput, 
		bButtonMainFwOut 		=> fbSeparateModule.bButtonAxisFwIn, 
		bButtonMainBwOut 		=> fbSeparateModule.bButtonAxisBwIn, 
		bButtonMetalFwOut 		=> fbMetalSorting.bButtonAxisFwIn, 
		bButtonMetalBwOut 		=> fbMetalSorting.bButtonAxisBwIn, 
		bButtonPlasticFwOut		=> fbPlasticSorting.bButtonAxisFwIn, 
		bButtonPlasticBwOut		=> fbPlasticSorting.bButtonAxisBwIn, 
		bButtonClampToWorkOut 	=> fbSeparateModule.bButtonClampToWorkIn, 
		bButtonBarrierToWorkOut	=> fbSeparateModule.bButtonBarrierToWorkIn, 
		bButtonMetalToWorkOut 	=> fbMetalSorting.bButtonCylToWorkIn, 
		bButtonPlasticToWorkOut	=> fbPlasticSorting.bButtonCylToWorkIn);
	
// =========================================================
END_ACTION

END_PROGRAM

// ---- POUs/Modules/FB_SeparatingModule.TcPOU
FUNCTION_BLOCK FB_SeparatingModule EXTENDS FB_Module
// Module to separate via sensor, barrier and clamp cylinder and axis
VAR_INPUT
		(***** Information about the state and mode of machine *****)
	bExecute					: BOOL;
	bSemiStart					: BOOL;
		(****** Variables to enable / disable diagnosis and temperature mode ******)
	bClampDiag					: BOOL;
	bClampTemp					: BOOL;
	bClampRecord				: BOOL;
	bBarrierDiag				: BOOL;
	bBarrierTemp				: BOOL;
	bBarrierRecord				: BOOL;
		(***** Timer values for clamp and barrier cylinder *****)
	tiTimeOutClamp				: TIME;
	tiTimeOutBarrier			: TIME;
	tiRecordIntervallClamp		: TIME;
	tiRecordIntervallBarrier	: TIME;
	tiBarrierAtWork				: TIME;
		(***** Information about number of boxes being sorted *****)
	iBoxesOnTheWay				: INT;
		(***** Buttons *****)
	bButtonClampToWorkIn		: BOOL;
	bButtonClampToBaseIn		: BOOL;
	bButtonBarrierToWorkIn		: BOOL;
	bButtonBarrierToBaseIn		: BOOL;
END_VAR
VAR_OUTPUT
	bClampToWork				: BOOL;
	bClampAtBase				: BOOL;
	bClampAtWork				: BOOL;
	bBarrierToWork				: BOOL;
	bBarrierAtBase				: BOOL;
	bBarrierAtWork				: BOOL;
	bClampError					: BOOL;
	sClampErrorMsg				: STRING;
	bBarrierError				: BOOL;
	sBarrierErrorMsg			: STRING;
	lrClampTemps				: ARRAY[1..100] OF LREAL;
	lrBarrierTemps				: ARRAY[1..100] OF LREAL;
	bSeparated					: BOOL;
	bButtonClampToWorkOut		: BOOL;
	bButtonClampToBaseOut		: BOOL;
	bButtonBarrierToWorkOut		: BOOL;
	bButtonBarrierToBaseOut		: BOOL;
END_VAR
VAR
(* ================= Function block and interface instances ===================== *)
	
	fbSensor					: FB_SignalHandling;
	
		(* Instances of clamp cylinder function blocks *)
	fbClamp						: FB_Cylinder;					// Without diagnosis and temperature mode
	fbClampDiag					: FB_CylinderDiag;				// With diagnosis of states
	fbClampTemp					: FB_CylinderTemp;				// With temperature mode
	fbClampTempDiag				: FB_CylinderTempDiag;			// With diagnosis of temperature
	fbClampTempRecord			: FB_CylinderTempRecord;		// With record of temperatures
		(* Interface instance of ICylinder for clamp cylinder *)
	iClamp						: ICylinder;
	
			(* Instances of barrier cylinder function blocks *)
	fbBarrier					: FB_Cylinder;					// Without diagnosis and temperature mode
	fbBarrierDiag				: FB_CylinderDiag;				// With diagnosis of states
	fbBarrierTemp				: FB_CylinderTemp;				// With temperature mode
	fbBarrierTempDiag			: FB_CylinderTempDiag;			// With diagnosis of temperature
	fbBarrierTempRecord			: FB_CylinderTempRecord;		// With record of temperatures
		(* Interface instance of ICylinder for barrier cylinder *)
	iBarrier					: ICylinder;
	
				(***** Manual cylinder control *****)
	fbButtonClampToWork			: FB_SignalHandlingIntern;		// To move manually clamp cylinder to work position
	fbButtonClampToBase			: FB_SignalHandlingIntern;		// To move manually clamp cylinder to base position
	fbButtonBarrierToWork		: FB_SignalHandlingIntern;		// To move manually barrier cylinder to work position
	fbButtonBarrierToBase		: FB_SignalHandlingIntern;		// To move manually barrier cylinder to base position
	
(* ========================== COMMON VARIABLES =============================== *)	
	tonBarrierAtWork			: TON;							// Timer for opening barrier in AUTOMATIC mode
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_Automatic
VAR_INPUT
END_VAR
// =========================================================
	// Noticing work position of barrier cylinder	

tonBarrierAtWork( PT := tiBarrierAtWork );

// =========================================================
	// Control of main axis

IF NOT bHalt THEN
	fbAxis.M_MoveFw();
ELSIF NOT bHaltDone THEN
	M_Stop();
ELSE
	bHalt := FALSE;
	M_Stop();
END_IF

// =========================================================
	// Process of separating boxes
	
CASE iState OF
	0:	// Init
		iBarrier.M_MoveToBase();					(***** Calling method of FB via interface *****)
		IF iBarrier.P_AtBasePos AND bExecute THEN	(***** Accessing property of FB via interface *****)
			iState := 1;
		END_IF
		
// =========================================================
	1: // Start
		IF fbSensor.bOut AND fbAxis.bMoves THEN
			iState := 2;
		ELSIF NOT iClamp.P_AtWorkPos THEN			(***** Accessing property of FB via interface instance *****)
			iClamp.M_MoveToWork();					(***** Calling method of FB via interface instance *****)
		END_IF
		
// =========================================================
	2: // Closing clamp
		iClamp.M_MoveToBase();						(***** Calling method of FB via interface instance *****)
		IF iClamp.P_AtBasePos THEN					(***** Accessing property of FB via interface instance *****)
			bSeparated := TRUE;
			iState := 3;
		END_IF
		
// =========================================================
	3: // Opening barrier
		iBarrier.M_MoveToWork();					(***** Calling method of FB via interface *****)
		
		IF iBarrier.P_AtWorkPos THEN				(***** Accessing property of FB via interface *****)
			tonBarrierAtWork( IN := TRUE );
		END_IF
		
		IF tonBarrierAtWork.Q THEN
			tonBarrierAtWork( IN := FALSE );
			iState := 4;
		END_IF
		
// =========================================================
	4:	// Closing barrier
		iBarrier.M_MoveToBase();					(***** Calling method of FB via interface *****)
		IF iBarrier.P_AtBasePos THEN				(***** Accessing property of FB via interface *****)
			bSeparated := FALSE;
			iState := 5;
		END_IF
		
// =========================================================
	5:	// Opening clamp
		iClamp.M_MoveToWork();						(***** Calling method of FB via interface instance *****)
		IF iClamp.P_AtWorkPos THEN					(***** Accessing property of FB via interface instance *****)
			iState := 0;
		END_IF
END_CASE

// =========================================================
END_METHOD

METHOD PUBLIC M_CylinderOptions
VAR_INPUT
END_VAR
// =========================================================
		// Selecting clamp cylinder

// Checking variables to enable / disable diagnosis and temperature mode
IF bClampDiag THEN
	IF bClampTemp THEN
		
	(* ============== FB with diagnosis and temperature mode ============== *)
		bClampError := fbClampTempDiag.bError;		// Assigning global output variable to output variable of selected FB
		sClampErrorMsg := fbClampTempDiag.sErrorMsg;
		iClamp := fbClampTempDiag;					// Assigning desired FB instance to interface instance
	
	ELSE
	
	(* ============== FB with diagnosis and without temperature mode ============== *)
		fbClampDiag.tiTimeOut := tiTimeOutClamp;	// Setting special data for selected FB
		bClampError := fbClampDiag.bError;			// Assigning global output variable to output variable of selected FB
		sClampErrorMsg := fbClampDiag.sErrorMsg;
		iClamp := fbClampDiag;						// Assigning desired FB instance to interface instance
	END_IF
ELSE
	bClampError := FALSE;
	sClampErrorMsg := '';
	
	IF bClampTemp THEN
		IF bClampRecord THEN
			fbClampTempRecord.tiIntervalTime := tiRecordIntervallClamp;	// Time of record interval
			fbClampTempRecord.bRecordStart := bComprAirEnabled;			// Recording if compressed air is set
			fbClampTempRecord.M_Record();								// Calling method of function block FB_CylinderTempRecord
			lrClampTemps := fbClampTempRecord.lrTemps;					// Saving output variable
			iClamp := fbClampTempRecord;
		ELSE
			(* ============== FB without diagnosis and with temperature mode ============== *)
			iClamp := fbClampTemp; 						// Assigning desired FB instance to interface instance
		END_IF
	ELSE
	
	(* ============== FB without diagnosis and temperature mode ============== *)
		iClamp := fbClamp;							// Assigning desired FB instance to interface instance						
	END_IF	
END_IF
									
// =========================================================
// =========================================================
			(**** Selecting barrier cylinder ****)

// Checking variables to enable / disable diagnosis and temperature mode
IF bBarrierDiag THEN
	IF bBarrierTemp THEN
		
	(* ============== FB with diagnosis and temperature mode ============== *)
		bBarrierError := fbBarrierTempDiag.bError;		// Assigning global output variable to output variable of selected FB
		sBarrierErrorMsg := fbBarrierTempDiag.sErrorMsg;
		iBarrier := fbBarrierTempDiag;					// Assigning desired FB instance to interface instance
	
	ELSE
	
	(* ============== FB with diagnosis and without temperature mode ============== *)
		fbBarrierDiag.tiTimeOut := tiTimeOutBarrier;	// Setting special data for selected FB
		bBarrierError := fbBarrierDiag.bError;			// Assigning global output variable to output variable of selected FB
		sBarrierErrorMsg := fbBarrierDiag.sErrorMsg;
		iBarrier := fbBarrierDiag;						// Assigning desired FB instance to interface instance
	END_IF
ELSE
	bBarrierError := FALSE;
	sBarrierErrorMsg := '';
	
	IF bBarrierTemp THEN
		IF bBarrierRecord THEN
			fbBarrierTempRecord.tiIntervalTime := tiRecordIntervallBarrier;// Time of record interval
			fbBarrierTempRecord.bRecordStart := bComprAirEnabled;			// Recording if compressed air is set
			fbBarrierTempRecord.M_Record();									// Calling method of function block FB_CylinderTempRecord
			lrBarrierTemps := fbBarrierTempRecord.lrTemps;					// Saving output variable
			iBarrier := fbBarrierTempRecord;
		ELSE
			(* ============== FB without diagnosis and with temperature mode ============== *)
			iBarrier := fbBarrierTemp; 						// Assigning desired FB instance to interface instance
		END_IF
	ELSE
	
	(* ============== FB without diagnosis and temperature mode ============== *)
		iBarrier := fbBarrier;							// Assigning desired FB instance to interface instance						
	END_IF	
END_IF
									
// =========================================================
END_METHOD

METHOD PUBLIC M_Enable
VAR_INPUT
END_VAR
// =========================================================
		// Calling method M_Enable of base class FB_Module via 'SUPER^.'
		
SUPER^.M_Enable();

// =========================================================
		// Sensor control
		
fbSensor.bEnable := bSensorEnable;

// =========================================================
		// Cylinder control
		
fbButtonClampToWork.bEnable := bManualCylinderEnable
								AND NOT iClamp.P_AtWorkPos;		(*** Accessing property of FB via interface instance ***)
fbButtonClampToBase.bInput := NOT fbButtonClampToWork.bInput;
fbButtonClampToBase.bEnable := bManualCylinderEnable
								AND NOT iClamp.P_AtBasePos;		(*** Accessing property of FB via interface instance ***)

fbButtonBarrierToWork.bEnable := bManualCylinderEnable
								AND NOT iBarrier.P_AtWorkPos;	(*** Accessing property of FB via interface instance ***)
fbButtonBarrierToBase.bInput := NOT fbButtonBarrierToWork.bInput;
fbButtonBarrierToBase.bEnable := bManualCylinderEnable
								AND NOT iBarrier.P_AtBasePos;	(*** Accessing property of FB via interface instance ***)

// =========================================================
END_METHOD

METHOD PUBLIC M_Maintenance
VAR_INPUT
END_VAR
// =========================================================
	// Calling own method M_Manual of this class FB_SeparatingModule via 'THIS^.'
		
THIS^.M_Manual();				

// =========================================================
END_METHOD

METHOD PUBLIC M_Manual
VAR_INPUT
END_VAR
// =========================================================
	// Calling method M_Manual of base class FB_Module via 'SUPER^.'
		
SUPER^.M_Manual();							

// =========================================================
	// Manual cylinder control
	
IF fbButtonClampToWork.bOut THEN
	iClamp.M_MoveToWork();					(**** Calling method of FB via interface instance ****)
ELSIF fbButtonClampToBase.bOut THEN
	iClamp.M_MoveToBase();					(**** Calling method of FB via interface instance ****)
END_IF

IF fbButtonBarrierToWork.bOut THEN
	iBarrier.M_MoveToWork();				(**** Calling method of FB via interface instance ****)
ELSIF fbButtonBarrierToBase.bOut THEN
	iBarrier.M_MoveToBase();				(**** Calling method of FB via interface instance ****)
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
		// Resetting cylinder and axis
		
rtrigResetStart( CLK := bReset );

IF rtrigResetStart.Q THEN
	bSeparated := FALSE;
	tonBarrierAtWork( IN := FALSE );
	iClamp.M_Reset();					(**** Calling method of FB via interface ****)
	iBarrier.M_Reset();					(**** Calling method of FB via interface ****)
END_IF

// =========================================================
		// Calling method of base class
		
SUPER^.M_Reset();						// Calling method M_Reset of base class FB_Module via 'SUPER^.'

// =========================================================
END_METHOD

METHOD PUBLIC M_Semiautomatic
VAR_INPUT
END_VAR
// =========================================================
	// Noticing work position of barrier cylinder	

tonBarrierAtWork( PT := tiBarrierAtWork );

// =========================================================
	// Control of main axis

IF iBoxesOnTheWay = 0 AND iState = 0 THEN
	bHalt := TRUE;
	M_Stop();
END_IF

IF bHalt THEN
	IF bHaltDone THEN
		bHalt := FALSE;
	END_IF
	M_Stop();
ELSE
	fbAxis.M_MoveFw();
END_IF

// =========================================================
	// Process of separating boxes
	
CASE iState OF
	0:	// Init
		iBarrier.M_MoveToBase();					(***** Calling method of FB via interface *****)
		IF iBarrier.P_AtBasePos						(***** Accessing property of FB via interface *****)
			AND bExecute AND bSemiStart THEN
				iState := 1;
		END_IF
		
// =========================================================
	1: // Start
		IF fbSensor.bOut THEN
			iState := 2;
		ELSE
			IF NOT iClamp.P_AtWorkPos THEN			(***** Accessing property of FB via interface instance *****)
				iClamp.M_MoveToWork();				(***** Calling method of FB via interface instance *****)
			END_IF
			fbAxis.M_MoveFw();
		END_IF
		
// =========================================================
	2: // Closing clamp
		iClamp.M_MoveToBase();						(***** Calling method of FB via interface instance *****)
		IF iClamp.P_AtBasePos THEN					(***** Accessing property of FB via interface instance *****)
			bSeparated := TRUE;
			iState := 3;
		END_IF
		
// =========================================================
	3: // Opening barrier
		iBarrier.M_MoveToWork();					(***** Calling method of FB via interface *****)
		
		IF iBarrier.P_AtWorkPos THEN				(***** Accessing property of FB via interface *****)
			tonBarrierAtWork( IN := TRUE );
		END_IF
		
		IF tonBarrierAtWork.Q THEN
			tonBarrierAtWork( IN := FALSE );
			iState := 4;
		END_IF
		
// =========================================================
	4:	// Closing barrier
		iBarrier.M_MoveToBase();					(***** Calling method of FB via interface *****)
		IF iBarrier.P_AtBasePos THEN				(***** Accessing property of FB via interface *****)
			bSeparated := FALSE;
			iState := 5;
		END_IF
		
// =========================================================
	5:	// Opening clamp
		iClamp.M_MoveToWork();						(***** Calling method of FB via interface instance *****)
		IF iClamp.P_AtWorkPos THEN					(***** Accessing property of FB via interface instance *****)
			iState := 0;
		END_IF
END_CASE

// =========================================================
END_METHOD

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
		// Calling method M_SetOutput of base class FB_Module via 'SUPER^.'
		
SUPER^.M_SetOutput();						

// =========================================================
		// Sensor
		
fbSensor.M_SetOutput();

// =========================================================
		// Cylinder buttons
		
fbButtonClampToWork.M_SetOutput();
fbButtonClampToBase.M_SetOutput();
fbButtonBarrierToWork.M_SetOutput();
fbButtonBarrierToBase.M_SetOutput();

// =========================================================
		// Output variables for cylinders
		
bClampToWork := iClamp.P_ToWork;			// Assigning global output variable to property of selected FB
											// Accessing property of selected FB via interface instance
bClampAtWork := iClamp.P_AtWorkPos;
bClampAtBase := iClamp.P_AtBasePos;
		
bBarrierToWork := iBarrier.P_ToWork;		// Assigning global output variable to property of selected FB
											// Accessing property of selected FB via interface instance
bBarrierAtWork := iBarrier.P_AtWorkPos;
bBarrierAtBase := iBarrier.P_AtBasePos;

// =========================================================
		// Buttons

fbButtonClampToWork.bInput := bButtonClampToWorkIn;
fbButtonClampToBase.bInput := bButtonClampToBaseIn;
fbButtonBarrierToWork.bInput := bButtonBarrierToWorkIn;
fbButtonBarrierToBase.bInput := bButtonBarrierToBaseIn;
bButtonClampToWorkOut := fbButtonClampToWork.bOut;
bButtonClampToBaseOut := fbButtonClampToBase.bOut;
bButtonBarrierToWorkOut := fbButtonBarrierToWork.bOut;
bButtonBarrierToBaseOut := fbButtonBarrierToBase.bOut;

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Modules/FB_Module.TcPOU
FUNCTION_BLOCK FB_Module
// Base class of modules with axis and buttons for manual control
VAR_INPUT
		(***** Enables *****)
	bComprAirEnabled			: BOOL;					// Enable of compressed air
	bAxisEnable					: BOOL;					// Enable of axis
	bSensorEnable				: BOOL;					// Enable of sensor
	bManualAxisEnable			: BOOL;					// Enable of manual axis control
		(***** State variables *****)
	bStarting					: BOOL;					// True if machine is in state STARTING
	bHalt						: BOOL;					// True if machine is in state ABORTING or STOPPING
	bReset						: BOOL;					// True if machine is in state RESETTING
		(**** Variables of axis *****)
	lrAxisVelo					: LREAL;				// Velocity of axis
	bButtonAxisFwIn				: BOOL;
	bButtonAxisBwIn				: BOOL;	
END_VAR
VAR_OUTPUT
	bAxisMoves					: BOOL;					// True if axis is moving
	bButtonAxisFwOut			: BOOL;
	bButtonAxisBwOut			: BOOL;				
	bStartingDone				: BOOL;					// True if module is started
	bHaltDone					: BOOL;					// True if module is stopped
	bResetDone					: BOOL;					// True if module is reset
	
		(***** Function block instance of FB_Axis *)
	fbAxis						: FB_Axis;
END_VAR
VAR
		(***** Manual axis control *****)
	fbButtonAxisFw				: FB_SignalHandlingIntern;	// To move axis forwards	
	fbButtonAxisBw				: FB_SignalHandlingIntern;	// To move axis backwards
	
(* ========================== COMMON VARIABLES =============================== *)	
	rtrigStartingStart			: R_TRIG;				// To diagnose rising edge of starting action starting
	rtrigHaltStart				: R_TRIG;				// To diagnose rising edge of starting halt
	rtrigResetStart				: R_TRIG;				// To diagnose rising edge of starting reset			
	bManualCylinderEnable		: BOOL;					// Enable of manual cylinder control
	iState						: INT;	
	bMoved						: BOOL;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_Enable
VAR_INPUT
END_VAR
// =========================================================
		// Axis control
		
fbAxis.bEnable := bAxisEnable;		// Setting variable to enable axis
fbAxis.M_Enable();					// Enabling axis

// =========================================================
		// Cylinder control
		
bManualCylinderEnable := bManualAxisEnable AND bComprAirEnabled;

// =========================================================
		// Axis control
		
fbButtonAxisFw.bEnable := bManualAxisEnable AND NOT fbButtonAxisBw.bOut;
fbButtonAxisBw.bEnable := bManualAxisEnable AND NOT fbButtonAxisFw.bOut;

// =========================================================
END_METHOD

METHOD PUBLIC M_Halt
VAR_INPUT
END_VAR
// =========================================================
		// Halting axis

fbAxis.bHalt := bHalt;				// Setting variable to halt axis
fbAxis.M_Halt();					// Halting axis

IF bHalt THEN
	bHaltDone := fbAxis.bHaltDone;	// Getting halt state
ELSE
	bHaltDone := FALSE;
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Manual
VAR_INPUT
END_VAR
// =========================================================
	// Manual axis control
	
IF fbButtonAxisBw.bOut THEN				(* Button to move axis backwards pressed *)
	IF bHaltDone THEN
		bHaltDone := FALSE;							// Resetting bHaltDone
	END_IF
	IF NOT bMoved THEN
		bMoved := TRUE;
	END_IF
	fbAxis.M_MoveBw();								// Move axis forwards
	
ELSIF fbButtonAxisFw.bOut THEN			(* Button to move axis forwards pressed *)
	IF bHaltDone THEN
		bHaltDone := FALSE;							// Resetting bHaltDone
	END_IF
	IF NOT bMoved THEN
		bMoved := TRUE;
	END_IF
	fbAxis.M_MoveFw();								// Move axis backwards
	
ELSIF NOT bHaltDone THEN				(* No button is pressed and halt is not done *)
	IF bMoved THEN								(* Request halt if axis has moved *)
		IF NOT bHalt THEN
			bHalt := TRUE;							// Setting variable to halt axis
		END_IF
		M_Halt();
	END_IF
	
ELSIF bHalt THEN						(* Halt is done but still requested *)
	bHalt := FALSE;									// Resetting variable to halt axis
	M_Halt();
	bMoved := FALSE;
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
		// Resetting variables

bMoved := FALSE;
bHaltDone := FALSE;
bHalt := FALSE;

// =========================================================
		// Resetting axis

fbAxis.bDriveReset := rtrigResetStart.Q;								
fbAxis.M_Reset();
bResetDone := fbAxis.bResetDone;

// =========================================================
END_METHOD

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
		// Axis buttons and output variable for axis
		
fbButtonAxisFw.M_SetOutput();	
fbButtonAxisBw.M_SetOutput();

bAxisMoves := fbAxis.bMoves;				// Getting moving state

fbButtonAxisFw.bInput := bButtonAxisFwIn;
fbButtonAxisBw.bInput := bButtonAxisBwIn;
bButtonAxisFwOut := fbButtonAxisFw.bOut;
bButtonAxisBwOut := fbButtonAxisBw.bOut;

// =========================================================
END_METHOD

METHOD PUBLIC M_Starting
VAR_INPUT
END_VAR
// =========================================================

rtrigStartingStart( CLK := bStarting );

IF rtrigStartingStart.Q THEN
	bStartingDone := FALSE;
	fbAxis.lrVelocity := lrAxisVelo;		// Setting velocity of axis
	iState := 0;							// Resetting state variable
END_IF

IF fbAxis.bStatus THEN
	bStartingDone := TRUE;
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Stop
VAR_INPUT
END_VAR
// =========================================================
		// Stopping axis

fbAxis.bHalt := bHalt;						// Setting variable to halt axis
fbAxis.M_Stop();							// Stopping axis

IF bHalt THEN
	bHaltDone := fbAxis.bHaltDone;			// Getting halt state
ELSE
	bHaltDone := FALSE;
END_IF

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Axis/FB_Axis.TcPOU
FUNCTION_BLOCK FB_Axis
VAR_INPUT
	bDriveReset		: BOOL;				// request reset
	bHalt			: BOOL;				// request stop
	bEnable			: BOOL;				// request enable
	lrVelocity 		: LREAL;			// target velocity
END_VAR
VAR_OUTPUT
	bStatus			: BOOL;				// feedback
	iErrorID		: DWORD;			// error ID
	bMoves			: BOOL;				// status of moving
	bHaltDone		: BOOL;				// status of function block MC_Halt
	bResetDone		: BOOL;				// status of function block MC_Reset
END_VAR
VAR
	lrOverride 		: LREAL := 100.0;	// override 100%
	rtrigHalt		: R_TRIG;
	rtrigReset		: R_TRIG;
	AxisRef			: AXIS_REF;			// axis reference (process data plc/nc)
	fbMcPower 		: MC_Power;			// enable and override
	fbMcReset 		: MC_Reset;			// reset axis
	fbMcStop 		: MC_Stop;			// stop motion
	fbMcHalt		: MC_Halt;			// halt motion
	fbMcMove		: MC_MoveVelocity;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_Enable
VAR_INPUT
END_VAR
// =========================================================

fbMCPower(	Enable 			:= bEnable, 
			Enable_Positive	:= bEnable, 
			Enable_Negative	:= bEnable, 
			Override		:= lrOverride,
			Axis			:= AxisRef,
			Status			=> bStatus	);
			
IF fbMcPower.Error THEN
	iErrorID := fbMcPower.ErrorID;
END_IF

AxisRef.ReadStatus();
bMoves := AxisRef.Status.Moving;

// =========================================================
END_METHOD

METHOD PUBLIC M_Halt
VAR_INPUT
END_VAR
// =========================================================

fbMCMove(Execute := FALSE, Axis := AxisRef);
rtrigHalt( CLK := bHalt );

IF rtrigHalt.Q THEN
	bHaltDone := FALSE;
	fbMcHalt(Execute := TRUE, Axis := AxisRef);
END_IF

IF NOT rtrigHalt.Q THEN
	fbMcHalt(Axis := AxisRef);
END_IF
	
IF fbMcHalt.Done OR fbMcHalt.Error OR fbMcHalt.CommandAborted THEN
	IF fbMcHalt.Error THEN
		iErrorID := fbMcHalt.ErrorID;
	END_IF
	
	fbMCMove(Execute := FALSE, Axis := AxisRef);
	fbMcHalt(Execute := FALSE, Axis := AxisRef);
END_IF

IF NOT fbMcHalt.Busy THEN
	bHaltDone := TRUE;
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_MoveBw
VAR_INPUT
END_VAR
// =========================================================

IF NOT fbMcMove.Error THEN
	fbMCMove(	Execute := TRUE,
				Velocity := lrVelocity,
				Direction := MC_Negative_Direction,
				Axis := AxisRef );
END_IF

IF fbMCMove.Error OR fbMCMove.CommandAborted THEN
	IF fbMcMove.Error THEN
		iErrorID := fbMCMove.ErrorID;
	END_IF
	fbMCMove(Execute := FALSE, Axis := AxisRef);
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_MoveFw
VAR_INPUT
END_VAR
// =========================================================

IF NOT fbMcMove.Error THEN
	fbMCMove(	Execute := TRUE,
				Velocity := lrVelocity,
				Direction := MC_Positive_Direction,
				Axis := AxisRef );
END_IF

IF fbMCMove.Error OR fbMCMove.CommandAborted THEN
	IF fbMcMove.Error THEN
		iErrorID := fbMCMove.ErrorID;
	END_IF
	fbMCMove(Execute := FALSE, Axis := AxisRef);
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================

rtrigReset( CLK := bDriveReset );

IF rtrigReset.Q THEN
	bResetDone := FALSE;
	bHaltDone := FALSE;
	fbMcReset(Execute := TRUE, Axis := AxisRef);
END_IF

fbMcReset(Axis := AxisRef);

IF fbMcReset.Done OR fbMcReset.Error THEN
	iErrorID := fbMcReset.ErrorID;
	fbMcReset(Execute := FALSE,	Axis := AxisRef);
	bResetDone := TRUE;
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Stop
VAR_INPUT
END_VAR
// =========================================================

fbMCMove(Execute := FALSE, Axis := AxisRef);
rtrigHalt( CLK := bHalt );

IF rtrigHalt.Q THEN
	bHaltDone := FALSE;
	fbMcStop(Execute := TRUE, Axis := AxisRef);
END_IF

IF NOT rtrigHalt.Q THEN
	fbMcStop(Axis := AxisRef);
END_IF

IF fbMcStop.Done OR fbMcStop.Error OR fbMcStop.CommandAborted THEN
	IF fbMcStop.Error THEN
		iErrorID := fbMcStop.ErrorID;
	END_IF
	
	fbMCMove(Execute := FALSE, Axis := AxisRef);
	fbMcStop(Execute := FALSE, Axis := AxisRef);
END_IF

IF NOT fbMcStop.Busy THEN
	bHaltDone := TRUE;
END_IF

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Signal handling/FB_SignalHandlingIntern.TcPOU
FUNCTION_BLOCK FB_SignalHandlingIntern IMPLEMENTS ISignalHandling
VAR_INPUT
	bInput		: BOOL;			// Input signal, e.g. sensor signal, enable for fuse
	bEnable		: BOOL;
END_VAR
VAR_OUTPUT
	bOut		: BOOL;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
	// Out
	
bOut := bInput AND bEnable;

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Signal handling/FB_SignalHandling.TcPOU
FUNCTION_BLOCK FB_SignalHandling IMPLEMENTS iSignalHandling
VAR_INPUT
	bInput		AT %I*: BOOL;			// Input signal, e.g. sensor signal, fuse
	bEnable		: BOOL;
END_VAR
VAR_OUTPUT
	bOut		AT %Q* : BOOL;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
	// Out
	
bOut := bInput AND bEnable;

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Cylinder/FB_Cylinder.TcPOU
FUNCTION_BLOCK FB_Cylinder IMPLEMENTS ICylinder
(* FB_Cylinder	- number of control signals
						one direction is controllable
				- type of feedback signal
						feedback in base and work position			*)
VAR_INPUT
	bAtBasePos		AT %I*: BOOL;
	bAtWorkPos		AT %I*: BOOL;
END_VAR
VAR_OUTPUT
	bMoveToWork		: BOOL;
END_VAR

// =========================================================
;
// =========================================================

METHOD M_MoveToBase : BOOL
VAR_INPUT
END_VAR
// =========================================================
	// Move to base position
	
M_MoveToBase := M_StateMachine(	bBasePosReq := TRUE,
								bWorkPosReq	:= FALSE );
								
// =========================================================
END_METHOD

METHOD M_MoveToWork : BOOL
VAR_INPUT
END_VAR
// =========================================================
	// Move to work position
	
M_MoveToWork := M_StateMachine(	bBasePosReq := FALSE,
								bWorkPosReq	:= TRUE );
								
// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
	// Reset
	
bMoveToWork := FALSE;

// =========================================================
END_METHOD

METHOD M_StateMachine : BOOL
VAR_INPUT
	bBasePosReq		: BOOL;
	bWorkPosReq		: BOOL;
END_VAR
// =========================================================
		// Base or work position requested
		
IF bWorkPosReq THEN
	bMoveToWork := TRUE;
END_IF
IF bBasePosReq OR NOT bWorkPosReq THEN
	bMoveToWork := FALSE;
END_IF

// =========================================================
	// Return
	
M_StateMachine := FALSE;

// =========================================================
END_METHOD

PROPERTY PUBLIC P_AtBasePos : BOOL
GET
P_AtBasePos := bAtBasePos;
END_GET
SET
END_SET
END_PROPERTY

PROPERTY PUBLIC P_AtWorkPos : BOOL
GET
P_AtWorkPos := bAtWorkPos;
END_GET
SET
END_SET
END_PROPERTY

PROPERTY PUBLIC P_ToWork : BOOL
GET
P_ToWork := bMoveToWork;
END_GET
SET
END_SET
END_PROPERTY

END_FUNCTION_BLOCK

// ---- POUs/Cylinder/FB_CylinderDiag.TcPOU
FUNCTION_BLOCK FB_CylinderDiag EXTENDS FB_Cylinder
(* FB_CylinderDiag	- number of control signals
							one direction is controllable
					- type of feedback signal
							feedback in base and work position
					- with diagnosis									*)
VAR_INPUT
	tiTimeOut 	 	: TIME;
END_VAR
VAR_OUTPUT
	bError			: BOOL;
	sErrorMsg		: STRING;
END_VAR
VAR
	rtrigError		: R_TRIG;
	bErrorMove		: BOOL;
	WatchDogTimer	: TON;
END_VAR

// =========================================================
;
// =========================================================

METHOD M_Diag : BOOL
VAR_INPUT
END_VAR
// =========================================================
	// Timer starts when cylinder is not in base and work position
	
IF NOT bAtBasePos AND NOT bAtWorkPos THEN
	WatchDogTimer(IN := TRUE, PT := tiTimeOut);
ELSE
	WatchDogTimer(IN := FALSE, PT := tiTimeOut);
END_IF

// =========================================================
	// Error if cylinder does not reach base or work position
	
rtrigError( CLK := WatchDogTimer.Q );
bError := WatchDogTimer.Q;

IF rtrigError.Q THEN
	bErrorMove := bMoveToWork;
END_IF

IF bError THEN
	IF bErrorMove = bMoveToWork THEN
		IF bMoveToWork THEN
			sErrorMsg := 'Work position not reached';
		ELSE
			sErrorMsg := 'Base position not reached';
		END_IF
	ELSE
		bError := FALSE;
		sErrorMsg := '';
	END_IF
ELSE
	sErrorMsg := '';
END_IF

// =========================================================
	// Return
	
M_Diag := bError;

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
	// Reset
	
SUPER^.M_Reset();		// Calling method M_Reset of base class FB_Cylinder via 'SUPER^.'
bError := FALSE;
sErrorMsg := '';

// =========================================================
END_METHOD

METHOD M_StateMachine : BOOL
VAR_INPUT
	bBasePosReq		: BOOL;
	bWorkPosReq		: BOOL;
END_VAR
// =========================================================
	// Call the method M_StateMachine of base class FB_Cylinder via 'SUPER^.'

SUPER^.M_StateMachine(	bBasePosReq := bBasePosReq,
						bWorkPosReq	:= bWorkPosReq );

// =========================================================
	// Additional diagnosis

M_StateMachine := M_Diag();

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Cylinder/FB_CylinderTemp.TcPOU
FUNCTION_BLOCK FB_CylinderTemp EXTENDS FB_Cylinder
VAR_INPUT
	lrTempCurrent		AT %I*: LREAL;
END_VAR

// =========================================================
;
// =========================================================

END_FUNCTION_BLOCK

// ---- POUs/Cylinder/FB_CylinderTempDiag.TcPOU
FUNCTION_BLOCK FB_CylinderTempDiag EXTENDS FB_CylinderTemp
VAR_INPUT
	lrTempMax		AT %I*: LREAL;
	lrTempMin		AT %I*: LREAL;
END_VAR
VAR_OUTPUT
	bError			: BOOL;
	sErrorMsg		: STRING;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_Diag : BOOL
VAR_INPUT
END_VAR
// =========================================================
	// Error if temperatur of cylinder is not in accepted interval
	
bError := NOT (lrTempCurrent >= lrTempMin AND lrTempCurrent <= lrTempMax);

IF bError THEN
	IF lrTempCurrent > lrTempMax THEN
		sErrorMsg := 'Temperature above maximum';
	ELSE
		sErrorMsg := 'Temperature below minimum';
	END_IF
ELSE
	sErrorMsg := '';
END_IF

// =========================================================
	// Return
	
M_Diag := bError;

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
	// Reset
	
SUPER^.M_Reset();		// Calling method M_Reset of base class FB_Cylinder via 'SUPER^.'
bError := FALSE;
sErrorMsg := '';

// =========================================================
END_METHOD

METHOD PUBLIC M_StateMachine : BOOL
VAR_INPUT
	bBasePosReq		: BOOL;
	bWorkPosReq		: BOOL;
END_VAR
// =========================================================

IF NOT bError THEN
	
		// Call the method M_StateMachine of base class FB_Cylinder via 'SUPER^.'
	SUPER^.M_StateMachine(	bBasePosReq := bBasePosReq,
							bWorkPosReq	:= bWorkPosReq );
	
		// Additional diagnosis
	M_StateMachine := M_Diag();
	
END_IF

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Cylinder/FB_CylinderTempRecord.TcPOU
FUNCTION_BLOCK FB_CylinderTempRecord EXTENDS FB_CylinderTemp
VAR_INPUT
	bRecordStart		: BOOL;
	tiIntervalTime		: TIME;
END_VAR
VAR_OUTPUT
	bRecordDone			: BOOL;
	lrTemps				: ARRAY[1..100] OF LREAL;
END_VAR
VAR
	IntervalTimer		: TON;
	iIndex				: INT;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_Record
VAR_INPUT
END_VAR
// =========================================================
	// Recording array filled
	
bRecordDone := (iIndex = 100);

// =========================================================
	// Recording temperatures
	
IF bRecordStart AND NOT bRecordDone AND NOT IntervalTimer.Q THEN
	IntervalTimer( IN := TRUE, PT := tiIntervalTime );
END_IF

IF IntervalTimer.Q THEN
	IntervalTimer( IN := FALSE );
	iIndex := iIndex + 1;
	lrTemps[iIndex] := lrTempCurrent;
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
	// Reset
	
SUPER^.M_Reset();					// Calling method M_Reset of base class FB_Cylinder via 'SUPER^.'

FOR iIndex := 1 TO 100 BY 1 DO
	lrTemps[iIndex] := 0;
END_FOR

iIndex := 0;

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Modules/FB_SortingModule.TcPOU
FUNCTION_BLOCK FB_SortingModule EXTENDS FB_Module
// Module to select via sensor, cylinder and axis
VAR_INPUT
		(* Variables to enable / disable diagnosis and temperature mode *)
	bCylinderDiag				: BOOL;
	bCylinderTemp				: BOOL;
	bCylinderRecord				: BOOL;
		(* Buttons *)
	bButtonCylToWorkIn			: BOOL;
	bButtonCylToBaseIn			: BOOL;
		(* Timer values *)
	tiTimeOutCylinder			: TIME;
	tiRecordIntervall			: TIME;
	tiSensorDelay				: TIME;
	tiMoveAxis					: TIME;					// Time to move axis
END_VAR
VAR_OUTPUT
	bToWork						: BOOL;
	bAtBase						: BOOL;
	bAtWork						: BOOL;
	bCylError					: BOOL;
	sCylErrorMsg				: STRING;
	lrTemps						: ARRAY[1..100] OF LREAL;
	bSelected					: BOOL;
	bButtonCylToWorkOut			: BOOL;
	bButtonCylToBaseOut			: BOOL;
END_VAR
VAR
(* ================= Function block and interface instances ===================== *)
	
	fbSensorDelay				: FB_SignalHandlingDelay;
		(* Instances of cylinder function blocks *)
	fbCylinder					: FB_Cylinder;					// Without diagnosis and temperature mode
	fbCylinderDiag				: FB_CylinderDiag;				// With diagnosis of states
	fbCylinderTemp				: FB_CylinderTemp;				// With temperature mode
	fbCylinderTempDiag			: FB_CylinderTempDiag;			// With diagnosis of temperature
	fbCylinderTempRecord		: FB_CylinderTempRecord;		// With record of temperatures
		(* Interface instance of ICylinder for cylinder *)
	iCyl						: ICylinder;
	
		(***** Manual cylinder control *****)
	fbButtonCylToWork			: FB_SignalHandlingIntern;		// To move manually cylinder to work position
	fbButtonCylToBase			: FB_SignalHandlingIntern;		// To move manually cylinder to base position

(* ========================== COMMON VARIABLES =============================== *)
	tonAxis						: TON;							// Timer to move axis in (SEMI-) AUTOMATIC mode	
	rtrigCylAtWork				: R_TRIG;						// To diagnose rising edge of being in work position
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_Automatic
VAR_INPUT
END_VAR
// =========================================================
		// Selecting boxes via cylinder and axis

tonAxis( PT := tiMoveAxis );
rtrigCylAtWork( CLK := iCyl.P_AtWorkPos );			(***** Accessing property of FB via interface *****)

IF rtrigCylAtWork.Q THEN
	tonAxis( IN := TRUE );
END_IF

IF bSelected THEN
	bSelected := FALSE;
END_IF

IF tonAxis.Q THEN
	tonAxis( IN := FALSE );
	bSelected := TRUE;
	bHalt := TRUE;
	M_Stop();
ELSIF tonAxis.IN AND NOT bHalt THEN
	fbAxis.M_MoveFw();
END_IF

IF NOT bHaltDone THEN
	IF bHalt THEN
		M_Stop();
	END_IF
ELSE
	bHalt := FALSE;
	M_Stop();
END_IF

// =========================================================

CASE iState OF
	0:	// Detecting a box
		iCyl.M_MoveToBase();						(***** Calling method of FB via interface *****)
		IF fbSensorDelay.bOut THEN
			iState := 1;
		END_IF
			
	1: 	// Moving cylinder to work position
		iCyl.M_MoveToWork();						(***** Calling method of FB via interface *****)
		IF iCyl.P_AtWorkPos THEN					(***** Accessing property of FB via interface *****)
			iState := 2;
		END_IF
	
	2:	// Moving cylinder back to base position
		iCyl.M_MoveToBase();						(***** Calling method of FB via interface *****)	
		IF iCyl.P_AtBasePos THEN					(***** Accessing property of FB via interface *****)
			iState := 0;
		END_IF
END_CASE

// =========================================================
END_METHOD

METHOD PUBLIC M_CylinderOptions
VAR_INPUT
END_VAR
// =========================================================
			// Selecting cylinder

// Checking variables to enable / disable diagnosis and temperature mode
IF bCylinderDiag THEN
	IF bCylinderTemp THEN
		
	(* ============== FB with diagnosis and temperature mode ============== *)
		bCylError := fbCylinderTempDiag.bError;		// Assigning global output variable to output variable of selected FB
		sCylErrorMsg := fbCylinderTempDiag.sErrorMsg;
		iCyl := fbCylinderTempDiag;					// Assigning desired FB instance to interface instance
	
	ELSE
	
	(* ============== FB with diagnosis and without temperature mode ============== *)
		fbCylinderDiag.tiTimeOut := tiTimeOutCylinder;			// Setting special data for selected FB
		bCylError := fbCylinderDiag.bError;			// Assigning global output variable to output variable of selected FB
		sCylErrorMsg := fbCylinderDiag.sErrorMsg;
		iCyl := fbCylinderDiag;						// Assigning desired FB instance to interface instance
	END_IF
ELSE
	bCylError := FALSE;
	sCylErrorMsg := '';
	
	IF bCylinderTemp THEN
		IF bCylinderRecord THEN
			fbCylinderTempRecord.tiIntervalTime := tiRecordIntervall;	// Time of record interval
			fbCylinderTempRecord.bRecordStart := bComprAirEnabled;		// Recording if compressed air is set
			fbCylinderTempRecord.M_Record();							// Calling method of function block FB_CylinderTempRecord
			lrTemps := fbCylinderTempRecord.lrTemps;					// Saving output variable
			iCyl := fbCylinderTempRecord;
		ELSE
			(* ============== FB without diagnosis and with temperature mode ============== *)
			iCyl := fbCylinderTemp; 						// Assigning desired FB instance to interface instance
		END_IF
	ELSE
	
	(* ============== FB without diagnosis and temperature mode ============== *)
		iCyl := fbCylinder;							// Assigning desired FB instance to interface instance						
	END_IF	
END_IF
									
// =========================================================
END_METHOD

METHOD PUBLIC M_Enable
VAR_INPUT
END_VAR
// =========================================================
		// Calling method M_Enable of base class FB_Module via 'SUPER^.'
		
SUPER^.M_Enable();

// =========================================================
		// Sensor control
		
fbSensorDelay.bEnable := bSensorEnable;

// =========================================================
		// Cylinder control
		
fbButtonCylToWork.bEnable := bManualCylinderEnable
								AND NOT iCyl.P_AtWorkPos;		(*** Accessing property of FB via interface instance ***)
fbButtonCylToBase.bInput := NOT fbButtonCylToWork.bInput;
fbButtonCylToBase.bEnable := bManualCylinderEnable
								AND NOT iCyl.P_AtBasePos;		(*** Accessing property of FB via interface instance ***)

// =========================================================
END_METHOD

METHOD PUBLIC M_Maintenance
VAR_INPUT
END_VAR
// =========================================================
		// Calling own method M_Manual of this class FB_SortingModule via 'THIS^.'
		
THIS^.M_Manual();

// =========================================================
END_METHOD

METHOD PUBLIC M_Manual
VAR_INPUT
END_VAR
// =========================================================
		// Calling method M_Manual of base class FB_Module via 'SUPER^.'
		
SUPER^.M_Manual();

// =========================================================
	// Manual cylinder control
	
IF fbButtonCylToWork.bOut THEN
	iCyl.M_MoveToWork();				(**** Calling method of FB via interface instance ****)
ELSIF fbButtonCylToBase.bOut THEN
	iCyl.M_MoveToBase();				(**** Calling method of FB via interface instance ****)
END_IF

// =========================================================
END_METHOD

METHOD PUBLIC M_Reset
VAR_INPUT
END_VAR
// =========================================================
		// Resetting cylinder and axis
		
rtrigResetStart( CLK := bReset );

IF rtrigResetStart.Q THEN
	bSelected := FALSE;
	tonAxis( IN := FALSE );
	iCyl.M_Reset();						(**** Calling method of FB via interface ****)
END_IF

// =========================================================
		// Calling method of base class
		
SUPER^.M_Reset();						// Calling action M_Reset of base class FB_Module via 'SUPER^.'

// =========================================================
END_METHOD

METHOD PUBLIC M_Semiautomatic
VAR_INPUT
END_VAR
// =========================================================
		// Calling own method M_Automatic of this class FB_SortingModule via 'THIS^.'
		
THIS^.M_Automatic();				

// =========================================================
END_METHOD

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
		// Calling method M_SetOutput of base class FB_Module via 'SUPER^.'
		
SUPER^.M_SetOutput();

// =========================================================
		// Sensor
		
fbSensorDelay.M_SetOutput();

// =========================================================
		// Cylinder buttons
		
fbButtonCylToWork.M_SetOutput();
fbButtonCylToBase.M_SetOutput();

// =========================================================
		// Output variables for cylinder
		
bToWork := iCyl.P_ToWork;			// Assigning global output variable to property of selected FB
									// Accessing property of selected FB via interface instance
bAtBase := iCyl.P_AtBasePos;
bAtWork := iCyl.P_AtWorkPos;

// =========================================================
		// Buttons
		
fbButtonCylToWork.bInput := bButtonCylToWorkIn;
fbButtonCylToBase.bInput := bButtonCylToBaseIn;
bButtonCylToWorkOut := fbButtonCylToWork.bOut;
bButtonCylToBaseOut := fbButtonCylToBase.bOut;

// =========================================================
END_METHOD

METHOD PUBLIC M_Starting
VAR_INPUT
END_VAR
// =========================================================
		// Setting time to delay sensor
		
fbSensorDelay.tiDelay := tiSensorDelay;

// =========================================================
		// Calling method M_Starting of base class FB_Module via 'SUPER^.'
		
SUPER^.M_Starting();

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Signal handling/FB_SignalHandlingDelay.TcPOU
FUNCTION_BLOCK FB_SignalHandlingDelay EXTENDS FB_SignalHandling
VAR_INPUT
	tiDelay			: TIME;
END_VAR
VAR
	bSet			: BOOL;
	tonDelay		: TON;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
	// Out

IF bEnable AND bInput THEN
	bSet := TRUE;
END_IF

IF bSet THEN
	tonDelay(IN := TRUE,
				PT := tiDelay);
ELSE
	tonDelay(IN := FALSE);
END_IF

IF tonDelay.Q THEN
	bSet := FALSE;
	tonDelay(IN := FALSE);
	bOut := TRUE;
ELSE
	bOut := FALSE;
END_IF
			
// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/FB_Visu.TcPOU
FUNCTION_BLOCK FB_Visu
VAR_INPUT
	(***** Sensors to detect boxes *****)
	bBarrierSensor				AT %I*: BOOL;	// True if barrier sensor detects a box
	bMetalSensor				AT %I*: BOOL;	// True if metal sensor detects a metal box
	bPlasticSensor				AT %I*: BOOL;	// True if plastic sensor detects a box
	
	bError						: BOOL;			// True if modules have errors
(***** Axis variables *****)
	lrAxisVelo					: LREAL;
	
(***** State of machine elements *****)
	bComprAirEnabled			: BOOL;			// True if compressed air is enabled
	bPowerEnabled				: BOOL;			// True if power supply is enabled
	bMainAxisMoves				: BOOL;			// True if main axis is moving
	bMetalAxisMoves				: BOOL;			// True if metal axis is moving
	bPlasticAxisMoves			: BOOL;			// True if plastic axis is moving
	bClampToWork				: BOOL;			// True if clamp cylinder moves to work position
	bBarrierToWork				: BOOL;			// True if barrier cylinder moves to work position
	bMetalToWork				: BOOL;			// True if metal cylinder moves to work position
	bPlasticToWork				: BOOL;			// True if plastic cylinder moves to work position
(***** Error *****)
	bClampError					: BOOL;			// True if clamp cylinder has an error
	sClampErrMsg				: STRING;			// Error message of clamp cylinder
	bMetalCylError				: BOOL;			// True if metal cylinder has an error
	sMetalErrMsg				: STRING;			// Error message of metal cylinder
	bPlasticCylError			: BOOL;			// True if plastic cylinder has an error
	sPlasticErrMsg				: STRING;			// Error message of plastic cylinder
	iMainAxisErrorId			: DWORD;			// Error id of main axis
	iMetalAxisErrorId			: DWORD;			// Error id of metal axis
	iPlasticAxisErrorId			: DWORD;			// Error id of plastic axis
	
(***** PS_PackML_StateMachine *****)
	bStarted					: BOOL;			// True if state machine is in state EXECUTE
	bStopped					: BOOL;			// True if state machine is in state STOPPED
	bReset						: BOOL;			// True if state machine is in state RESETTING
	bAborted					: BOOL;			// True if state machine is in state ABORTED
	bIdle						: BOOL;			// True if state machine is in state IDLE
	bAuto						: BOOL;			// True if state machine is in mode AUTOMATIC
	bSemi						: BOOL;			// True if state machine is in mode SEMIAUTOMATIC
	bManual						: BOOL;			// True if state machine is in mode MANUAL
	bMaintenance				: BOOL;			// True if state machine is in mode MAINTENANCE
	bStartButtonOff				: BOOL;			// To turn off start button

(***** Buttons of visualisation - inputs *****)
		(* State buttons *)
	bButtonPowerIn				: BOOL;			// Input signal of power button
	bButtonComprAirIn			: BOOL;			// Input signal of compressed air button
	bButtonStartIn				: BOOL;			// Input signal of start button
	bButtonStopIn				: BOOL;			// Input signal of stop button
	bButtonResetIn				: BOOL;			// Input signal of reset button
	bButtonAbortIn				: BOOL;			// Input signal of abort button
		(* Mode buttons *)
	bButtonAutoIn				: BOOL;			// Input signal of automatic button
	bButtonSemiIn				: BOOL;			// Input signal of semi-automatic button
	bButtonManuIn				: BOOL;			// Input signal of manual button
	bButtonMaintenanceIn		: BOOL;			// Input signal of maintenance button
		(* Axis buttons *)
	bButtonMainFwIn				: BOOL;			// Input signal of button to move main axis forwards
	bButtonMainBwIn				: BOOL;			// Input signal of button to move main axis backwards
	bButtonMetalFwIn			: BOOL;			// Input signal of button to move metal axis forwards
	bButtonMetalBwIn			: BOOL;			// Input signal of button to move metal axis backwards
	bButtonPlasticFwIn			: BOOL;			// Input signal of button to move plastic axis forwards
	bButtonPlasticBwIn			: BOOL;			// Input signal of button to move plastic axis backwards
		(* Cylinder buttons *)
	bButtonClampToWorkIn		: BOOL;			// Input signal of button to move clamp cylinder
	bButtonBarrierToWorkIn		: BOOL;			// Input signal of button to move barrier cylinder
	bButtonMetalToWorkIn		: BOOL;			// Input signal of button to move metal cylinder
	bButtonPlasticToWorkIn		: BOOL;			// Input signal of button to move plastic cylinder
END_VAR
VAR_OUTPUT
	lrYClamp					AT %Q*: LREAL;					// Y-Coordinate of clamp cylinder
	lrYBarrier					AT %Q*: LREAL;					// Y-Coordinate of barrier cylinder
	lrYMetal					AT %Q*: LREAL;					// Y-Coordinate of metal cylinder
	lrYPlastic					AT %Q*: LREAL;					// Y-Coordinate of plastic cylinder
	lrBoxX						AT %Q*: ARRAY[1..4] OF LREAL;	// X-Coordinates of boxes
	lrBoxY						AT %Q*: ARRAY[1..4] OF LREAL;	// Y-Coordinates of boxes
	
(***** Buttons of visualisation - outputs *****)
		(* State buttons *)
	bButtonPowerOut				: BOOL;			// To turn on and off the machine
	bButtonComprAirOut			: BOOL;			// To enable compressed air
	bButtonStartOut				: BOOL;			// To change state into state START
	bButtonStopOut				: BOOL;			// To change state into state STOP
	bButtonResetOut				: BOOL;			// To change state into state RESET
	
		(* Mode buttons *)
	bButtonAutoOut				: BOOL;			// To change mode into mode AUTOMATIC		
	bButtonSemiOut				: BOOL;			// To change mode into mode SEMI-AUTOMATIC	
	bButtonManuOut				: BOOL;			// To change mode into mode MANAUL	
	bButtonMaintenanceOut		: BOOL;			// To change mode into mode MAINTENANCE	
	
		(* Axis buttons *)
	bButtonMainFwOut			: BOOL;			// To move main axis forwards
	bButtonMainBwOut			: BOOL;			// To move main axis backwards
	bButtonMetalFwOut			: BOOL;			// To move metal axis forwards
	bButtonMetalBwOut			: BOOL;			// To move metal axis backwards
	bButtonPlasticFwOut			: BOOL;			// To move plastic axis forwards
	bButtonPlasticBwOut			: BOOL;			// To move plastic axis backwards
	
		(* Cylinder buttons *)
	bButtonClampToWorkOut		: BOOL;			// To move manually clamp cylinder to work position
	bButtonBarrierToWorkOut		: BOOL;			// To move manually barrier cylinder to work position
	bButtonMetalToWorkOut		: BOOL;			// To move manually metal cylinder to work position
	bButtonPlasticToWorkOut		: BOOL;			// To move manually plastic cylinder to work position
END_VAR
VAR
	iBoxesLast					: INT;						// Box on last position of main belt
	bBoxMetalMove				: ARRAY[1..4] OF BOOL;		// bBoxMetalMove[1] is true, if box 1 is moved by metal cylinder
	bBoxMetalFree				: ARRAY[1..4] OF BOOL;		// bBoxMetalFree[1] is true, if any box blockades the metal belt
	bBoxPlasticMove				: ARRAY[1..4] OF BOOL;		// bBoxPlasticMove[1] is true, if box 1 is moved by plastic cylinder
	bBoxPlasticFree				: ARRAY[1..4] OF BOOL;		// bBoxMetalFree[1] is true, if any box blockades the plastic belt
	bBoxMainBelt				: ARRAY[1..4] OF BOOL;		// bBoxMainBelt[1] is true, if box 1 is on main belt and has no
	bBoxMetalBelt				: ARRAY[1..4] OF BOOL;				// obstacles, so box 1 is moved by main axis
	bBoxPlasticBelt				: ARRAY[1..4] OF BOOL;
	lrMainVelo					: LREAL;					// Velocity of boxes on main belt
	lrMetalVelo					: LREAL;					// Velocity of boxes on metal belt
	lrPlasticVelo				: LREAL;					// Velocity of boxes on plastic belt
	bAccident					: BOOL;						// True if machine caused an accident
	iState						: INT;
	
	iMessages					: INT;						// Number of messages
	sMessageClamp				: STRING;					// Message of clamp cylinder
	sMessageMetalCyl			: STRING;					// Message of metal cylinder
	sMessagePlasticCyl			: STRING;					// Message of plastic cylinder
	sMessageMainAxis			: STRING;					// Message of main axis
	sMessageMetalAxis			: STRING;					// Message of metal axis
	sMessagePlasticAxis			: STRING;					// Message of plastic axis
	iAngleMain					: INT;						// Angle of main axis element
	iAngleMetal					: INT;						// Angle of metal axis element
	iAnglePlastic				: INT;						// Angle of plastic axis element
	tonMainAxis					: TON;						// Timer for movement of main axis element
	tonMetalAxis				: TON;						// Timer for movement of metal axis element
	tonPlasticAxis				: TON;						// Timer for movement of plastic axis element

(* ========================== COLOR VARIABLES =============================== *)

	dwYellow					: DWORD;
	dwGreen						: DWORD;
	dwPink						: DWORD;
	dwButtonColorStart			: DWORD;					// Color of start button
	bButtonColorStart			: BOOL;						// To change color of start button
	dwButtonColorStop			: DWORD;					// Color of stop button
	bButtonColorStop			: BOOL;						// To change color of stop button
	dwButtonColorReset			: DWORD;					// Color of reset button
	bButtonColorReset			: BOOL;						// To change color of reset button
	dwButtonColorAuto			: DWORD;					// Color of automatic button
	bButtonColorAuto			: BOOL;						// To change color of automatic button
	dwButtonColorSemi			: DWORD;					// Color of semi-automatic button
	bButtonColorSemi			: BOOL;						// To change color of semi-automatic button
	dwButtonColorManu			: DWORD;					// Color of manual button
	bButtonColorManu			: BOOL;						// To change color of manual button
	dwButtonColorMaint			: DWORD;					// Color of maintenance button
	bButtonColorMaint			: BOOL;						// To change color of maintenance button
	dwButtonColorClamp			: DWORD;					// Color of button to move clamp cylinder
	bButtonColorClamp			: BOOL;						// To change color of clamp button
	dwButtonColorBarrier		: DWORD;					// Color of button to move barrier cylinder
	bButtonColorBarrier			: BOOL;						// To change color of barrier button
	dwButtonColorMetalCyl		: DWORD;					// Color of button to move metal cylinder
	bButtonColorMetalCyl		: BOOL;						// To change color of metal cylinder button
	dwButtonColorPlasticCyl		: DWORD;					// Color of button to move plastic cylinder
	bButtonColorPlasticCyl		: BOOL;						// To change color of plastic cylinder button
	dwButtonColorMainFw			: DWORD;					// Color of button to move main axis forwards
	bButtonColorMainFw			: BOOL;						// To change color of button to move main axis fw.
	dwButtonColorMainBw			: DWORD;					// Color of button to move main axis backwards
	bButtonColorMainBw			: BOOL;						// To change color of button to move main axis bw.
	dwButtonColorMetalFw		: DWORD;					// Color of button to move metal axis forwards
	bButtonColorMetalFw			: BOOL;						// To change color of button to move metal axis fw.
	dwButtonColorMetalBw		: DWORD;					// Color of button to move metal axis backwards
	bButtonColorMetalBw			: BOOL;						// To change color of button to move metal axis bw.
	dwButtonColorPlasticFw		: DWORD;					// Color of button to move plastic axis forwards
	bButtonColorPlasticFw		: BOOL;						// To change color of button to move plastic axis fw.
	dwButtonColorPlasticBw		: DWORD;					// Color of button to move plastic axis backwards
	bButtonColorPlasticBw		: BOOL;						// To change color of button to move plastic axis bw.
	dwButtonColorComprAir		: DWORD;					// Color of button to enable/disable compressed air
	bButtonColorComprAir		: BOOL;						// To change color of button to control compressed air
END_VAR

// =========================================================
	// Resetting visu
	
IF bReset THEN
	M_Reset();
END_IF

// =========================================================
	// Because of the visualisation size
	// the boxes velocity is a fraction of the axis velocity
	
IF bAuto OR bSemi OR bButtonMainFwIn THEN
	lrMainVelo := lrAxisVelo / 250;
ELSIF bButtonMainBwIn THEN
	lrMainVelo := - lrAxisVelo / 250;
END_IF
IF bAuto OR bSemi OR bButtonMetalFwIn THEN
	lrMetalVelo := - lrAxisVelo / 250;
ELSIF bButtonMetalBwIn THEN
	lrMetalVelo := lrAxisVelo / 250;
END_IF
IF bAuto OR bSemi OR bButtonPlasticFwIn THEN
	lrPlasticVelo := - lrAxisVelo / 250;
ELSIF bButtonPlasticBwIn THEN
	lrPlasticVelo := lrAxisVelo / 250;
END_IF

// =========================================================
	// In case of accident the power button is turned off
	
IF bAccident THEN
	IF bButtonPowerOut THEN
		bButtonPowerOut := FALSE;
	END_IF
	IF bStopped THEN
		bAccident := FALSE;
	END_IF
END_IF

// =========================================================
	// Rotation of axis elements
M_AxisRotation();

	// Buttons, order of boxes, error messages
M_ButtonSignals();
M_ButtonColors();
M_LastBox();
M_ErrorMessages();

	// Motion of cylinders
M_Barrier_Clamp_Cyl();
M_Metal_Plastic_Cyl();

	// Motion of boxes
M_AxisMoveBoxes();
M_CylinderMoveBoxes();

// =========================================================

METHOD PRIVATE M_AxisMoveBoxes
VAR_INPUT
END_VAR
// =========================================================
	// Checking traction standby on main belt
	
bBoxMainBelt[1] := lrBoxY[1] >= -5	// box 1 on main belt
						// not previous to box 2											
					AND ((lrBoxX[2] - lrBoxX[1] - lrMainVelo) >= 119.99999 OR (lrBoxX[2] - lrBoxX[1] - lrMainVelo) <= 0.001 OR lrBoxY[2] < -60)
						// not previous to box 3	
					AND ((lrBoxX[3] - lrBoxX[1] - lrMainVelo) >= 179.99999 OR (lrBoxX[3] - lrBoxX[1]- lrMainVelo) <= 60.001 OR lrBoxY[3] < -60)
						// not previous to box 4
					AND ((lrBoxX[4] - lrBoxX[1] - lrMainVelo) >= 239.99999 OR (lrBoxX[4] - lrBoxX[1]- lrMainVelo) <= 120.001 OR lrBoxY[4] < -60);
					
bBoxMainBelt[2] := lrBoxY[2] >= -5
					AND ((lrBoxX[1] - lrBoxX[2] - lrMainVelo) >= -0.00001 OR (lrBoxX[1] - lrBoxX[2] - lrMainVelo) <= -119.999 OR lrBoxY[1] < -60)
					AND ((lrBoxX[3] - lrBoxX[2] - lrMainVelo) >= 119.99999 OR (lrBoxX[3] - lrBoxX[2] - lrMainVelo) <= 0.001 OR lrBoxY[3] < -60)
					AND ((lrBoxX[4] - lrBoxX[2] - lrMainVelo) >= 179.99999 OR (lrBoxX[4] - lrBoxX[2] - lrMainVelo) <= 60.001 OR lrBoxY[4] < -60);

bBoxMainBelt[3] := lrBoxY[3] >= -5
					AND ((lrBoxX[1] - lrBoxX[3] - lrMainVelo) >= -60.00001 OR (lrBoxX[1] - lrBoxX[3] - lrMainVelo) <= -179.999 OR lrBoxY[1] < -60)
					AND ((lrBoxX[2] - lrBoxX[3] - lrMainVelo) >= -0.00001 OR (lrBoxX[2] - lrBoxX[3] - lrMainVelo) <= -119.999 OR lrBoxY[2] < -60)
					AND ((lrBoxX[4] - lrBoxX[3] - lrMainVelo) >= 119.99999 OR (lrBoxX[4] - lrBoxX[3] - lrMainVelo) <= 0.001 OR lrBoxY[4] < -60);
					
bBoxMainBelt[4] := lrBoxY[4] >= -5
					AND ((lrBoxX[1] - lrBoxX[4] - lrMainVelo) >= -120.00001 OR (lrBoxX[1] - lrBoxX[4] - lrMainVelo) <= -239.999 OR lrBoxY[1] < -60)
					AND ((lrBoxX[2] - lrBoxX[4] - lrMainVelo) >= -60.00001 OR (lrBoxX[2] - lrBoxX[4] - lrMainVelo) <= -179.999 OR lrBoxY[2] < -60)
					AND ((lrBoxX[3] - lrBoxX[4] - lrMainVelo) >= -0.00001 OR (lrBoxX[3] - lrBoxX[4] - lrMainVelo) <= -119.999 OR lrBoxY[3] < -60);
					
// =========================================================
	// Motion of boxes on main belt - forwards
					
IF bMainAxisMoves AND (bAuto OR bSemi OR bButtonMainFwIn) THEN
	FOR iState := 1 TO 4 BY 1 DO
		IF bBoxMainBelt[iState] THEN	
				// not previous to moving metal cylinder
			IF lrBoxX[iState] >= (60*iState + 30) AND lrBoxX[iState] < (260 + 60*iState) THEN
				IF lrYMetal <= -9 THEN
					IF lrBoxX[iState] < (131.25 + 60*iState) AND lrBoxX[iState] > (130.95 + 60*iState) THEN
						lrBoxX[iState] := 131 + 60*iState;
					ELSIF lrBoxX[iState] <= (130.95 + 60*iState) THEN
						lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
					END_IF
				ELSE
					lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
				END_IF
			END_IF
				// not previous to moving plastic cylinder
			IF lrBoxX[iState] >= (260 + 60*iState) THEN
				IF lrYPlastic <= -9 THEN
					IF lrBoxX[iState] < (381.25 + 60*iState) AND lrBoxX[iState] > (380.95 + 60*iState) THEN
						lrBoxX[iState] := 381 + 60*iState;
					ELSIF lrBoxX[iState] <= (380.95 + 60*iState) THEN
						lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
					END_IF
				ELSE
					lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
				END_IF
			END_IF
				// barrier open and box 1 in the first place
			IF lrYBarrier >= 61 AND lrBoxX[iState] >= 60*(iState - 1) AND lrBoxX[iState] <  (60*iState + 30) THEN
				IF lrBoxX[iState] + lrMainVelo < (60*iState + 30) THEN
					 lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
				ELSIF lrBoxX[iState] < (60*iState + 30) THEN
					lrBoxX[iState] := (60*iState + 30);
				END_IF
			END_IF	
				// not previous to clamp
			IF lrBoxX[iState] + lrMainVelo < -60*(3 - iState) THEN
				lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
			ELSIF lrBoxX[iState] < -60*(iState + 1) THEN
				lrBoxX[iState] := -60*(iState + 1);
			END_IF
				// clamp open, not after clamp											
			IF lrYClamp >= 1 AND lrBoxX[iState] >= -60*(iState + 1) THEN
				IF lrBoxX[iState] + lrMainVelo < 60*(iState - 1) THEN
					lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
				ELSIF lrBoxX[iState] < 60*(iState - 1) THEN
					lrBoxX[iState] := 60*(iState - 1);
				END_IF
			END_IF
		END_IF
	END_FOR
END_IF

// =========================================================
	// Motion of boxes on main belt - backwards
	
IF bMainAxisMoves AND bButtonMainBwIn THEN 
	FOR iState := 1 TO 4 BY 1 DO
		IF bBoxMainBelt[iState] THEN
				// not previous to moving metal cylinder
			IF lrBoxX[iState] >= (90 + 60*iState) AND lrBoxX[iState] < (262 + 60*iState) THEN
				IF NOT (lrBoxX[iState] < (261.25 + 60*iState) AND lrBoxX[iState] > (260.95 + 60*iState) AND lrYMetal <= -9) THEN
					lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
				ELSE
					lrBoxX[iState] := 261 + 60*iState;
				END_IF
			END_IF
				// not previous to moving plastic cylinder
			IF lrBoxX[iState] >=  (262 + 60*iState) THEN
				lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
			END_IF
				// not previous to moving barrier cylinder
			IF lrBoxX[iState] > 60*(iState - 1) AND lrBoxX[iState] < (90 + 60*iState) THEN
				IF NOT (lrBoxX[iState] < (30.25 + 60*iState) AND lrBoxX[iState] > (29.95 + 60*iState) AND lrYBarrier < 61) THEN
					lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
				ELSE
					lrBoxX[iState] := 60*iState + 30;
				END_IF
			END_IF
				// barrier open and box 1 after the first place
			IF lrYBarrier >= 61 AND lrBoxX[iState] < 60*(iState + 1) AND lrBoxX[iState] > 60*(iState - 1) THEN
				lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
			END_IF	
				// clamp open, not previous to clamp											
			IF lrYClamp >= 1 AND lrBoxX[iState] <= 60*(iState-1) AND lrBoxX[iState] > -60*(3-iState) THEN
				lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
			END_IF
				// not at the beginning of main belt
			IF lrBoxX[iState] > -60*(4-iState) AND lrBoxX[iState] <= -60*(3-iState) THEN
				lrBoxX[iState] := lrBoxX[iState] + lrMainVelo;
			END_IF
		END_IF
	END_FOR	
END_IF

// =========================================================
// =========================================================
	// Checking traction standby on metal belt
	
bBoxMetalBelt[1] := lrBoxX[1] > 240 AND lrBoxX[1] <= 271	// box 1 on metal belt
						// not previous to box 2											
					AND ((lrBoxY[2] - lrBoxY[1] - lrMetalVelo) >= 60 OR (lrBoxY[2] - lrBoxY[1] - lrMetalVelo) <= -60
							OR NOT (lrBoxX[2] > 300 AND lrBoxX[2] <= 331))
						// not previous to box 3	
					AND ((lrBoxY[3] - lrBoxY[1]- lrMetalVelo) >= 60 OR (lrBoxY[3] - lrBoxY[1]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[3] > 360 AND lrBoxX[3] <= 391))
						// not previous to box 4
					AND ((lrBoxY[4] - lrBoxY[1]- lrMetalVelo) >= 60 OR (lrBoxY[4] - lrBoxY[1]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[4] > 420 AND lrBoxX[4] <= 451));	
					
bBoxMetalBelt[2] := lrBoxX[2] > 300 AND lrBoxX[2] <= 331										
					AND ((lrBoxY[1] - lrBoxY[2] - lrMetalVelo) >= 60 OR (lrBoxY[1] - lrBoxY[2] - lrMetalVelo) <= -60
							OR NOT (lrBoxX[1] > 240 AND lrBoxX[1] <= 271))
					AND ((lrBoxY[3] - lrBoxY[2]- lrMetalVelo) >= 60 OR (lrBoxY[3] - lrBoxY[2]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[3] > 360 AND lrBoxX[3] <= 391))
					AND ((lrBoxY[4] - lrBoxY[2]- lrMetalVelo) >= 60 OR (lrBoxY[4] - lrBoxY[2]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[4] > 420 AND lrBoxX[4] <= 451));	
					
bBoxMetalBelt[3] := lrBoxX[3] > 360 AND lrBoxX[3] <= 391										
					AND ((lrBoxY[1] - lrBoxY[3] - lrMetalVelo) >= 60 OR (lrBoxY[1] - lrBoxY[3] - lrMetalVelo) <= -60
							OR NOT (lrBoxX[1] > 240 AND lrBoxX[1] <= 271))
					AND ((lrBoxY[2] - lrBoxY[3]- lrMetalVelo) >= 60 OR (lrBoxY[2] - lrBoxY[3]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[2] > 300 AND lrBoxX[2] <= 331))
					AND ((lrBoxY[4] - lrBoxY[3]- lrMetalVelo) >= 60 OR (lrBoxY[4] - lrBoxY[3]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[4] > 420 AND lrBoxX[4] <= 451));	
					
bBoxMetalBelt[4] := lrBoxX[4] > 420 AND lrBoxX[4] <= 451										
					AND ((lrBoxY[1] - lrBoxY[4] - lrMetalVelo) >= 60 OR (lrBoxY[1] - lrBoxY[4] - lrMetalVelo) <= -60
							OR NOT (lrBoxX[1] > 240 AND lrBoxX[1] <= 271))
					AND ((lrBoxY[2] - lrBoxY[4] - lrMetalVelo) >= 60 OR (lrBoxY[2] - lrBoxY[4] - lrMetalVelo) <= -60
							OR NOT (lrBoxX[2] > 300 AND lrBoxX[2] <= 331))
					AND ((lrBoxY[3] - lrBoxY[4]- lrMetalVelo) >= 60 OR (lrBoxY[3] - lrBoxY[4]- lrMetalVelo) <= -60
							OR NOT (lrBoxX[3] > 360 AND lrBoxX[3] <= 391));

// =========================================================
	// Motion of boxes on metal belt and back to the start position number 4
	
FOR iState := 1 TO 4 BY 1 DO	
	IF bMetalAxisMoves THEN
		IF 	bBoxMetalBelt[iState] THEN
		(* Check the state and direction of motion *)		
				IF bAuto OR bSemi OR (NOT bAuto AND bButtonMetalFwIn) THEN
				(* Move box to the end of metal belt and then back to position 4 *)	
					IF lrBoxY[iState] <= -64.9 AND lrBoxY[iState] > -140.0 THEN
						lrBoxY[iState] := lrBoxY[iState] + lrMetalVelo;
					END_IF
				ELSIF NOT bAuto AND bButtonMetalBwIn THEN
					IF lrBoxY[iState] + lrMetalVelo <= -65.1 THEN
						lrBoxY[iState] := lrBoxY[iState] + lrMetalVelo;
					END_IF
				END_IF
		END_IF
	END_IF	
	
	IF lrBoxY[iState] <= -140.0 AND iBoxesLast = 0 THEN
		lrBoxY[iState] := 0;
		lrBoxX[iState] := -240 + iState*60;
	END_IF
END_FOR
	
// =========================================================
// =========================================================
	// Checking traction standby on plastic belt
	
bBoxPlasticBelt[1] := lrBoxX[1] > 470 AND lrBoxX[1] <= 521	// box 1 on plastic belt
						// not previous to box 2											
					AND ((lrBoxY[2] - lrBoxY[1] - lrPlasticVelo) >= 60 OR (lrBoxY[2] - lrBoxY[1] - lrPlasticVelo) <= -60
							OR NOT (lrBoxX[2] > 530 AND lrBoxX[2] <= 581))
						// not previous to box 3	
					AND ((lrBoxY[3] - lrBoxY[1]- lrPlasticVelo) >= 60 OR (lrBoxY[3] - lrBoxY[1]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[3] > 590 AND lrBoxX[3] <= 641))
						// not previous to box 4
					AND ((lrBoxY[4] - lrBoxY[1]- lrPlasticVelo) >= 60 OR (lrBoxY[4] - lrBoxY[1]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[4] > 650 AND lrBoxX[4] <= 701));	
					
bBoxPlasticBelt[2] := lrBoxX[2] > 530 AND lrBoxX[2] <= 581										
					AND ((lrBoxY[1] - lrBoxY[2] - lrPlasticVelo) >= 60 OR (lrBoxY[1] - lrBoxY[2] - lrPlasticVelo) <= -60
							OR NOT (lrBoxX[1] > 470 AND lrBoxX[1] <= 521))
					AND ((lrBoxY[3] - lrBoxY[2]- lrPlasticVelo) >= 60 OR (lrBoxY[3] - lrBoxY[2]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[3] > 590 AND lrBoxX[3] <= 641))
					AND ((lrBoxY[4] - lrBoxY[2]- lrPlasticVelo) >= 60 OR (lrBoxY[4] - lrBoxY[2]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[4] > 650 AND lrBoxX[4] <= 701));	
					
bBoxPlasticBelt[3] := lrBoxX[3] > 590 AND lrBoxX[3] <= 641										
					AND ((lrBoxY[1] - lrBoxY[3] - lrPlasticVelo) >= 60 OR (lrBoxY[1] - lrBoxY[3] - lrPlasticVelo) <= -60
							OR NOT (lrBoxX[1] > 470 AND lrBoxX[1] <= 521))
					AND ((lrBoxY[2] - lrBoxY[3]- lrPlasticVelo) >= 60 OR (lrBoxY[2] - lrBoxY[3]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[2] > 530 AND lrBoxX[2] <= 581))
					AND ((lrBoxY[4] - lrBoxY[3]- lrPlasticVelo) >= 60 OR (lrBoxY[4] - lrBoxY[3]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[4] > 650 AND lrBoxX[4] <= 701));	
					
bBoxPlasticBelt[4] := lrBoxX[4] > 650 AND lrBoxX[4] <= 701										
					AND ((lrBoxY[1] - lrBoxY[4] - lrPlasticVelo) >= 60 OR (lrBoxY[1] - lrBoxY[4] - lrPlasticVelo) <= -60
							OR NOT (lrBoxX[1] > 470 AND lrBoxX[1] <= 521))
					AND ((lrBoxY[2] - lrBoxY[4] - lrPlasticVelo) >= 60 OR (lrBoxY[2] - lrBoxY[4] - lrPlasticVelo) <= -60
							OR NOT (lrBoxX[2] > 530 AND lrBoxX[2] <= 581))
					AND ((lrBoxY[3] - lrBoxY[4]- lrPlasticVelo) >= 60 OR (lrBoxY[3] - lrBoxY[4]- lrPlasticVelo) <= -60
							OR NOT (lrBoxX[3] > 590 AND lrBoxX[3] <= 641));

// =========================================================
	// Motion of boxes on metal belt and back to the start position number 4

FOR iState := 1 TO 4 BY 1 DO	
	IF bPlasticAxisMoves THEN
			IF 	bBoxPlasticBelt[iState] THEN	
				(* Check the state and direction of motion *)		
				IF bAuto OR bSemi OR (NOT bAuto AND bButtonPlasticFwIn) THEN
				(* Move box to the end of metal belt and then back to position 4 *)	
					IF lrBoxY[iState] <= -64.9 AND lrBoxY[iState] > -140.0 THEN
							lrBoxY[iState] := lrBoxY[iState] + lrPlasticVelo;
					END_IF
				ELSIF NOT bAuto AND bButtonPlasticBwIn THEN
					IF lrBoxY[iState] + lrPlasticVelo <= -65.1 THEN
						lrBoxY[iState] := lrBoxY[iState] + lrPlasticVelo;
					END_IF
				END_IF
			END_IF
	END_IF
	
	IF lrBoxY[iState] <= -140.0 AND iBoxesLast = 0 THEN
		lrBoxY[iState] := 0;
		lrBoxX[iState] := -240 + iState*60;
	END_IF
END_FOR

// =========================================================
END_METHOD

METHOD PRIVATE M_AxisRotation
VAR_INPUT
END_VAR
// =========================================================
	// Rotation of main axis
	
tonMainAxis( IN := bMainAxisMoves,
			 PT := T#0.04S );

IF tonMainAxis.Q THEN
	tonMainAxis( IN := FALSE );
	IF bAuto OR bSemi THEN
		iAngleMain := iAngleMain + 2;
	ELSIF bButtonMainFwIn THEN
		iAngleMain := iAngleMain + 1;
	ELSIF bButtonMainBwIn THEN
		iAngleMain := iAngleMain - 1;
	END_IF
END_IF

// =========================================================
	// Rotation of metal axis
	
tonMetalAxis( IN := bMetalAxisMoves,
			 PT := T#0.04S );

IF tonMetalAxis.Q THEN
	tonMetalAxis( IN := FALSE );
	IF bAuto OR bSemi THEN
		iAngleMetal := iAngleMetal + 2;
	ELSIF bButtonMetalFwIn THEN
		iAngleMetal := iAngleMetal + 1;
	ELSIF bButtonMetalBwIn THEN
		iAngleMetal := iAngleMetal - 1;
	END_IF
END_IF

// =========================================================
	// Rotation of plastic axis
	
tonPlasticAxis( IN := bPlasticAxisMoves,
			 PT := T#0.04S );

IF tonPlasticAxis.Q THEN
	tonPlasticAxis( IN := FALSE );
	IF bAuto OR bSemi THEN
		iAnglePlastic := iAnglePlastic + 2;
	ELSIF bButtonPlasticFwIn THEN
		iAnglePlastic := iAnglePlastic + 1;
	ELSIF bButtonPlasticBwIn THEN
		iAnglePlastic := iAnglePlastic - 1;
	END_IF
END_IF

// =========================================================
END_METHOD

METHOD PRIVATE M_Barrier_Clamp_Cyl
VAR_INPUT
END_VAR
// =========================================================
	// Moving clamp cylinder
	
IF bClampToWork THEN
	IF (lrYClamp + 0.1) < 3.0 THEN
		lrYClamp := lrYClamp + 0.1;
	ELSE
		lrYClamp := 3.0;
	END_IF
ELSE
	IF (lrYClamp - 0.1) > 0.0 THEN
		lrYClamp := lrYClamp - 0.1;
	ELSE
		lrYClamp := 0.0;
	END_IF
END_IF

// =========================================================
// =========================================================
	// Moving barrier cylinder
	
IF bBarrierToWork THEN
	IF (lrYBarrier + 1) < 63.0 THEN
		lrYBarrier := lrYBarrier + 1;
	ELSE
		lrYBarrier := 63.0;
	END_IF
ELSE
	IF (lrYBarrier - 1) > 0.0 THEN
		lrYBarrier := lrYBarrier - 1;
	ELSE
		lrYBarrier := 0.0;
	END_IF
END_IF

// =========================================================
	// Checking position of boxes related to the barrier cylinder
	
IF lrYBarrier <= 60 AND NOT bBarrierToWork THEN
	FOR iState := 1 TO 4 BY 1 DO
		IF lrBoxX[iState] > (-59.89 + 60*iState) AND lrBoxX[iState] < (60*iState + 30) AND lrBoxY[iState] = 0
			AND NOT bStopped THEN
				bAccident := TRUE;
		END_IF
	END_FOR
END_IF

// =========================================================
END_METHOD

METHOD PRIVATE M_ButtonColors
VAR_INPUT
END_VAR
// =========================================================
		// Colors
		
dwYellow := 16#00FFFF80;
dwGreen := 16#0080FF00;
dwPink := 16#00FF8080;

// =========================================================
		// Start button
		
IF (bAccident OR (bPowerEnabled AND (NOT bStarted OR (bSemi AND bStarted))
	AND NOT bButtonStopIn AND NOT bButtonAbortIn AND NOT bButtonResetIn
	AND (bAuto OR bSemi OR bManual OR bMaintenance))) AND NOT (bError AND bIdle) THEN
		IF bButtonStartOut THEN
			dwButtonColorStart := dwGreen;
		ELSE
			dwButtonColorStart := dwYellow;
		END_IF
		bButtonColorStart := TRUE;
ELSE
	bButtonColorStart := FALSE;
END_IF

// =========================================================
		// Stop button
		
IF (bStarted OR bIdle) AND (bAuto OR bSemi OR bManual OR bMaintenance) THEN
	IF bButtonStopOut THEN
		dwButtonColorStop := dwGreen;
	ELSE
		dwButtonColorStop := dwYellow;
	END_IF
	bButtonColorStop := TRUE;
ELSE
	bButtonColorStop := FALSE;
END_IF

// =========================================================
		// Reset button
		
IF bStopped AND bPowerEnabled THEN
	IF bButtonResetOut THEN
		dwButtonColorReset := dwGreen;
	ELSE
		dwButtonColorReset := dwYellow;		
	END_IF
	bButtonColorReset := TRUE;
ELSE
	bButtonColorReset := FALSE;
END_IF

// =========================================================
		// Mode buttons

IF bPowerEnabled THEN
	IF NOT bAuto THEN
		IF bIdle THEN
			dwButtonColorAuto := dwYellow;
			bButtonColorAuto := TRUE;
		ELSE
			bButtonColorAuto := FALSE;
		END_IF
	ELSE
		dwButtonColorAuto := dwGreen;
		bButtonColorAuto := TRUE;
	END_IF
	
	IF NOT bSemi THEN
		IF bIdle THEN
			dwButtonColorSemi := dwYellow;
			bButtonColorSemi := TRUE;
		ELSE
			bButtonColorSemi := FALSE;
		END_IF
	ELSE
		dwButtonColorSemi := dwGreen;
		bButtonColorSemi := TRUE;
	END_IF
	
	IF NOT bManual THEN
		IF bIdle THEN
			dwButtonColorManu := dwYellow;
			bButtonColorManu := TRUE;
		ELSE
			bButtonColorManu := FALSE;
		END_IF
	ELSE
		dwButtonColorManu := dwGreen;
		bButtonColorManu := TRUE;
	END_IF
	
	IF NOT bMaintenance THEN
		IF bIdle THEN
			dwButtonColorMaint := dwYellow;
			bButtonColorMaint := TRUE;
		ELSE
			bButtonColorMaint := FALSE;
		END_IF
	ELSE
		dwButtonColorMaint := dwGreen;
		bButtonColorMaint := TRUE;
	END_IF
END_IF

// =========================================================
		// Buttons to move cylinders and axes
		
IF (bManual OR bMaintenance) AND bStarted THEN
// Cylinders
	IF bButtonClampToWorkOut THEN
		dwButtonColorClamp := dwPink;
	ELSE
		dwButtonColorClamp := dwYellow;
	END_IF
	IF bButtonBarrierToWorkOut THEN
		dwButtonColorBarrier := dwPink;
	ELSE
		dwButtonColorBarrier := dwYellow;
	END_IF
	IF bButtonMetalToWorkOut THEN
		dwButtonColorMetalCyl := dwPink;
	ELSE
		dwButtonColorMetalCyl := dwYellow;
	END_IF
	IF bButtonPlasticToWorkOut THEN
		dwButtonColorPlasticCyl := dwPink;
	ELSE
		dwButtonColorPlasticCyl := dwYellow;
	END_IF
	bButtonColorClamp := TRUE;
	bButtonColorBarrier := TRUE;
	bButtonColorMetalCyl := TRUE;
	bButtonColorPlasticCyl := TRUE;
	
// Axes
	IF bButtonMainBwOut THEN
		dwButtonColorMainBw := dwPink;
	ELSE
		dwButtonColorMainBw := dwYellow;
	END_IF
	IF bButtonMainFwOut THEN
		dwButtonColorMainFw := dwPink;
	ELSE
		dwButtonColorMainFw := dwYellow;
	END_IF
	
	IF bButtonMetalBwOut THEN
		dwButtonColorMetalBw := dwPink;
	ELSE
		dwButtonColorMetalBw := dwYellow;
	END_IF
	IF bButtonMetalFwOut THEN
		dwButtonColorMetalFw := dwPink;
	ELSE
		dwButtonColorMetalFw := dwYellow;
	END_IF
	
	IF bButtonPlasticBwOut THEN
		dwButtonColorPlasticBw := dwPink;
	ELSE
		dwButtonColorPlasticBw := dwYellow;
	END_IF
	IF bButtonPlasticFwOut THEN
		dwButtonColorPlasticFw := dwPink;
	ELSE
		dwButtonColorPlasticFw := dwYellow;
	END_IF
	
	bButtonColorMainBw := NOT bButtonMainFwOut;
	bButtonColorMainFw := NOT bButtonMainBwOut;
	bButtonColorMetalBw := NOT bButtonMetalFwOut;
	bButtonColorMetalFw := NOT bButtonMetalBwOut;
	bButtonColorPlasticBw := NOT bButtonPlasticFwOut;
	bButtonColorPlasticFw := NOT bButtonPlasticBwOut;
ELSE
	bButtonColorClamp := FALSE;
	bButtonColorBarrier := FALSE;
	bButtonColorMetalCyl := FALSE;
	bButtonColorPlasticCyl := FALSE;
	bButtonColorMainBw := FALSE;
	bButtonColorMainFw := FALSE;
	bButtonColorMetalBw := FALSE;
	bButtonColorMetalFw := FALSE;
	bButtonColorPlasticBw := FALSE;
	bButtonColorPlasticFw := FALSE;
END_IF
		
// =========================================================
		// Button to control compressed air
		
IF bMaintenance AND bStarted THEN
	IF bButtonComprAirIn THEN
		dwButtonColorComprAir := dwGreen;
	ELSE
		dwButtonColorComprAir := dwYellow;
	END_IF
	bButtonColorComprAir := TRUE;
ELSE
	bButtonColorComprAir := FALSE;
END_IF

// =========================================================
END_METHOD

METHOD PRIVATE M_ButtonSignals
VAR_INPUT
END_VAR
// =========================================================
	// When machine is in requested state, buttons are turned off again

IF bStartButtonOff THEN
	bButtonStartOut := FALSE;
END_IF

IF bStopped THEN
	bButtonStopOut := FALSE;
END_IF

IF bReset THEN
	bButtonResetOut := FALSE;
END_IF

IF bManual THEN
	bButtonManuOut := FALSE;
END_IF

IF bAuto THEN
	bButtonAutoOut := FALSE;
END_IF

IF bSemi THEN
	bButtonSemiOut := FALSE;
END_IF

IF bMaintenance THEN
	bButtonMaintenanceOut := FALSE;
END_IF

// =========================================================
END_METHOD

METHOD PRIVATE M_CylinderMoveBoxes
VAR_INPUT
END_VAR
// =========================================================
	// Metal cylinder - checking the positions of boxes
	
bBoxMetalFree[1] := NOT (lrBoxX[2] > 300 AND lrBoxX[2] <= 331 AND lrBoxY[1] - lrBoxY[2] <= 61)
					AND NOT (lrBoxX[3] > 360 AND lrBoxX[3] <= 391 AND lrBoxY[1] - lrBoxY[3] <= 61)
					AND NOT (lrBoxX[4] > 420 AND lrBoxX[4] <= 451 AND lrBoxY[1] - lrBoxY[4] <= 61);

bBoxMetalFree[2] := NOT (lrBoxX[1] > 240 AND lrBoxX[1] <= 271 AND lrBoxY[2] - lrBoxY[1] <= 61)
					AND NOT (lrBoxX[3] > 360 AND lrBoxX[3] <= 391 AND lrBoxY[2] - lrBoxY[3] <= 61)
					AND NOT (lrBoxX[4] > 420 AND lrBoxX[4] <= 451 AND lrBoxY[2] - lrBoxY[4] <= 61);
					
bBoxMetalFree[3] := NOT (lrBoxX[1] > 240 AND lrBoxX[1] <= 271 AND lrBoxY[3] - lrBoxY[1] <= 61)
					AND NOT (lrBoxX[2] > 300 AND lrBoxX[2] <= 331 AND lrBoxY[3] - lrBoxY[2] <= 61)
					AND NOT (lrBoxX[4] > 420 AND lrBoxX[4] <= 451 AND lrBoxY[3] - lrBoxY[4] <= 61);
					
bBoxMetalFree[4] := NOT (lrBoxX[1] > 240 AND lrBoxX[1] <= 271 AND lrBoxY[4] - lrBoxY[1] <= 61)
					AND NOT (lrBoxX[2] > 300 AND lrBoxX[2] <= 331 AND lrBoxY[4] - lrBoxY[2] <= 61)
					AND NOT (lrBoxX[3] > 360 AND lrBoxX[3] <= 391 AND lrBoxY[4] - lrBoxY[3] <= 61);

// =========================================================
	// Metal cylinder - boxes motion
	
FOR iState := 1 TO 4 BY 1 DO
	IF bMetalToWork AND bBoxMetalMove[iState] AND bBoxMetalFree[iState] THEN
		IF (lrYMetal - 1) >= -72 THEN
			lrYMetal := lrYMetal - 1;
			IF lrYMetal - lrBoxY[iState] <= -9 THEN
				lrBoxY[iState] := lrBoxY[iState] - 1;
			END_IF
		ELSIF lrYMetal = -72 AND (lrYMetal - lrBoxY[iState]) <= -9 THEN
			lrBoxY[iState] := lrBoxY[iState] - 2;
		ELSE
			bBoxMetalMove[iState] := FALSE;
		END_IF
	END_IF	
END_FOR

// =========================================================
// =========================================================
	// Plastic cylinder - checking the positions of boxes

bBoxPlasticFree[1] := NOT (lrBoxX[2] > 550 AND lrBoxX[2] <= 581 AND lrBoxY[1] - lrBoxY[2] <= 61)
					AND NOT (lrBoxX[3] > 610 AND lrBoxX[3] <= 641 AND lrBoxY[1] - lrBoxY[3] <= 61)
					AND NOT (lrBoxX[4] > 670 AND lrBoxX[4] <= 701 AND lrBoxY[1] - lrBoxY[4] <= 61);

bBoxPlasticFree[2] := NOT (lrBoxX[1] > 490 AND lrBoxX[1] <= 521 AND lrBoxY[2] - lrBoxY[1] <= 61)
					AND NOT (lrBoxX[3] > 610 AND lrBoxX[3] <= 641 AND lrBoxY[2] - lrBoxY[3] <= 61)
					AND NOT (lrBoxX[4] > 670 AND lrBoxX[4] <= 701 AND lrBoxY[2] - lrBoxY[4] <= 61);
					
bBoxPlasticFree[3] := NOT (lrBoxX[1] > 490 AND lrBoxX[1] <= 521 AND lrBoxY[3] - lrBoxY[1] <= 61)
					AND NOT (lrBoxX[2] > 550 AND lrBoxX[2] <= 581 AND lrBoxY[3] - lrBoxY[2] <= 61)
					AND NOT (lrBoxX[4] > 670 AND lrBoxX[4] <= 701 AND lrBoxY[3] - lrBoxY[4] <= 61);
					
bBoxPlasticFree[4] := NOT (lrBoxX[1] > 490 AND lrBoxX[1] <= 521 AND lrBoxY[4] - lrBoxY[1] <= 61)
					AND NOT (lrBoxX[2] > 550 AND lrBoxX[2] <= 581 AND lrBoxY[4] - lrBoxY[2] <= 61)
					AND NOT (lrBoxX[3] > 610 AND lrBoxX[3] <= 641 AND lrBoxY[4] - lrBoxY[3] <= 61);
					
// =========================================================
	// Plastic cylinder - boxes motion

FOR iState := 1 TO 4 BY 1 DO
	IF bPlasticToWork AND bBoxPlasticMove[iState] AND bBoxPlasticFree[iState] THEN
		IF (lrYPlastic - 1) >= -72 THEN
			lrYPlastic := lrYPlastic - 1;
			IF lrYPlastic - lrBoxY[iState] <= -9 THEN
				lrBoxY[iState] := lrBoxY[iState] - 1;
			END_IF
		ELSIF lrYPlastic = -72 AND (lrYPlastic - lrBoxY[iState]) <= -9 THEN
			lrBoxY[iState] := lrBoxY[iState] - 2;
		ELSE
			bBoxPlasticMove[iState] := FALSE;
		END_IF
	END_IF	
END_FOR

// =========================================================
END_METHOD

METHOD PRIVATE M_ErrorMessages
VAR_INPUT
END_VAR
// =========================================================
	// Error messages
	
iMessages := 0;
	
IF iMainAxisErrorId = 0 THEN
	sMessageMainAxis := '';
ELSE
	iMessages := iMessages + 1;
	sMessageMainAxis := CONCAT('Error ID of main axis: ', DWORD_TO_STRING(iMainAxisErrorId));
END_IF
// =========================================================
IF iMetalAxisErrorId = 0 THEN
	sMessageMetalAxis := '';
ELSE
	iMessages := iMessages + 1;
	sMessageMetalAxis := CONCAT('Error ID of metal axis: ', DWORD_TO_STRING(iMetalAxisErrorId));
END_IF
// =========================================================
IF iPlasticAxisErrorId = 0 THEN
	sMessagePlasticAxis := '';
ELSE
	iMessages := iMessages + 1;
	sMessagePlasticAxis := CONCAT('Error ID of plastic axis: ', DWORD_TO_STRING(iPlasticAxisErrorId));
END_IF
// =========================================================
IF bClampError THEN
	iMessages := iMessages + 1;
	sMessageClamp := CONCAT('Error of clamp cylinder: ', sClampErrMsg);
ELSE
	sMessageClamp := '';
END_IF
// =========================================================
IF bMetalCylError THEN
	iMessages := iMessages + 1;
	sMessageMetalCyl := CONCAT('Error of metal cylinder: ', sMetalErrMsg);
ELSE
	sMessageMetalCyl := '';
END_IF
// =========================================================
IF bPlasticCylError THEN
	iMessages := iMessages + 1;
	sMessagePlasticCyl := CONCAT('Error of plastic cylinder: ', sPlasticErrMsg);
ELSE
	sMessagePlasticCyl := '';
END_IF
// =========================================================
END_METHOD

METHOD PRIVATE M_LastBox
VAR_INPUT
END_VAR
// =========================================================
	// Checking the last position on main belt

IF lrBoxX[1] >= -180.05 AND lrBoxX[1] < -120.05 AND lrBoxY[1] = 0 THEN
	iBoxesLast := 1;
ELSIF lrBoxX[2] >= -120.05 AND lrBoxX[2] < -60.1 AND lrBoxY[2] = 0 THEN
	iBoxesLast := 2;	
ELSIF lrBoxX[3] >= -60.05 AND lrBoxX[3] < -0.05 AND lrBoxY[3] = 0 THEN
	iBoxesLast := 3;	
ELSIF lrBoxX[4] >= -0.05 AND lrBoxX[4] < 59.95 AND lrBoxY[4] = 0 THEN
	iBoxesLast := 4;	
ELSE
	iBoxesLast := 0;
END_IF		

// =========================================================
END_METHOD

METHOD PRIVATE M_Metal_Plastic_Cyl
VAR_INPUT
END_VAR
// =========================================================
	// Moving metal cylinder
	
IF bMetalToWork THEN
	IF NOT (bBoxMetalMove[1] OR bBoxMetalMove[2] OR bBoxMetalMove[3] OR bBoxMetalMove[4]) THEN
		IF (lrYMetal - 1) >= -73 THEN
			lrYMetal := lrYMetal - 1;
		END_IF
	ELSE
		FOR iState := 1 TO 4 BY 1 DO
			IF bBoxMetalMove[iState] THEN
				IF (lrYMetal - 1) >= (lrBoxY[iState] - 9.1) AND (lrYMetal - 1) >= -73 THEN
					lrYMetal := lrYMetal - 1;
				END_IF
			END_IF
		END_FOR
	END_IF
ELSE
	IF (lrYMetal + 1) < 0.0 THEN
		lrYMetal := lrYMetal + 1;
	ELSE
		lrYMetal := 0.0;
	END_IF
END_IF

// =========================================================
	// Checking position of boxes related to the metal cylinder
	
IF lrYMetal < -8.9 AND lrYMetal > -9.1 AND bMetalToWork THEN
	FOR iState := 1 TO 4 BY 1 DO
			// box on main belt
		IF lrBoxY[iState] >= -5 THEN
				// box in right position related to the metal cylinder
			IF lrBoxX[iState] > (180 + 60*iState) AND lrBoxX[iState] <= (211 + 60*iState) THEN
					bBoxMetalMove[iState] := TRUE;
			END_IF
				// box in wrong position related to the metal cylinder >> accident
			IF ((lrBoxX[iState] > (131 + 60*iState) AND lrBoxX[iState] <= (180 + 60*iState))
				OR (lrBoxX[iState] > (211 + 60*iState) AND lrBoxX[iState] < (261 + 60*iState)))
				AND NOT bStopped THEN
					bAccident := TRUE;
			END_IF
		END_IF
	END_FOR
END_IF

// =========================================================
// =========================================================
	// Moving plastic cylinder
	
IF bPlasticToWork THEN
	IF NOT (bBoxPlasticMove[1] OR bBoxPlasticMove[2] OR bBoxPlasticMove[3] OR bBoxPlasticMove[4]) THEN
		IF (lrYPlastic - 1) >= -73 THEN
			lrYPlastic := lrYPlastic - 1;
		END_IF
	ELSE
		FOR iState := 1 TO 4 BY 1 DO
			IF bBoxPlasticMove[iState] THEN
				IF (lrYPlastic - 1) >= (lrBoxY[iState] - 9.1) AND (lrYPlastic - 1) >= -73 THEN
					lrYPlastic := lrYPlastic - 1;
				END_IF
			END_IF
		END_FOR
	END_IF
ELSE
	IF (lrYPlastic + 1) < 0 THEN
		lrYPlastic := lrYPlastic + 1;
	ELSE
		lrYPlastic := 0;
	END_IF
END_IF

// =========================================================
	// Checking position of boxes related to the plastic cylinder
	
IF (lrBoxX[1] > 521 OR lrBoxX[2] > 581 OR lrBoxX[3] > 641 OR lrBoxX[4] > 701)
	AND NOT bStopped THEN
		bAccident := TRUE;
END_IF
	
IF lrYPlastic < -8.9 AND lrYPlastic > -9.1 AND bPlasticToWork THEN
	FOR iState := 1 TO 4 BY 1 DO
			// box on main belt
		IF lrBoxY[iState] >= -5 THEN
				// box in right position related to the plastic cylinder
			IF lrBoxX[iState] > (430 + 60*iState) AND lrBoxX[iState] <= (461 + 60*iState) THEN
					bBoxPlasticMove[iState] := TRUE;
			END_IF
				// box in wrong position related to the plastic cylinder >> accident
			IF lrBoxX[iState] > (381 + 60*iState) AND lrBoxX[iState] <= (430 + 60*iState)
				AND NOT bStopped THEN
					bAccident := TRUE;
			END_IF	
		END_IF
	END_FOR
END_IF

// =========================================================
END_METHOD

METHOD PRIVATE M_Reset
VAR_INPUT
END_VAR
// =========================================================
	// Resetting visu
	
// Cylinder buttons
bButtonClampToWorkOut := FALSE;
bButtonBarrierToWorkOut := FALSE;
bButtonMetalToWorkOut := FALSE;
bButtonPlasticToWorkOut := FALSE;

// Axis buttons
bButtonMainBwOut := FALSE;
bButtonMainFwOut := FALSE;
bButtonMetalBwOut := FALSE;
bButtonMetalFwOut := FALSE;
bButtonPlasticBwOut := FALSE;
bButtonPlasticFwOut := FALSE;

// State and mode buttons
bButtonStartOut := FALSE;
bButtonStopOut := FALSE;
bButtonResetOut := FALSE;
bButtonComprAirOut := FALSE;
bButtonManuOut := FALSE;
bButtonAutoOut := FALSE;
bButtonSemiOut := FALSE;
bButtonMaintenanceOut := FALSE;

// Position of boxes and cylinders	
FOR iState := 1 TO 4 BY 1 DO
	lrBoxX[iState] := 0;
	lrBoxY[iState] := 0;
	bBoxMetalMove[iState] := FALSE;
	bBoxPlasticMove[iState] := FALSE;
	bBoxMainBelt[iState] := FALSE;
	bBoxMetalBelt[iState] := FALSE;
	bBoxPlasticBelt[iState] := FALSE;
END_FOR

bAccident := FALSE;

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- POUs/Internal PackAL/PS_PackML_StateMachine_Auto.TcPOU
FUNCTION_BLOCK PS_PackML_StateMachine_Auto
VAR_IN_OUT
	Machine				: Machine_REF;
END_VAR
VAR_INPUT
	Start				: BOOL;
	Hold				: BOOL;
	UnHold				: BOOL;
	Suspend				: BOOL;
	UnSuspend			: BOOL;
	Abort				: BOOL;
	Stop				: BOOL;
	Complete			: BOOL;
	Clear				: BOOL;
	Reset				: BOOL;
	StateComplete		: BOOL;
END_VAR
VAR_OUTPUT
	Status				: WORD;

	ST_Starting			: BOOL;
	ST_Completing		: BOOL;
	ST_Resetting		: BOOL;
	ST_Holding			: BOOL;
	ST_UnHolding		: BOOL;
	ST_Suspending		: BOOL;
	ST_UnSuspending		: BOOL;
	ST_Clearing			: BOOL;
	ST_Stopping			: BOOL;
	ST_Aborting			: BOOL;

	(* State Complete*)
	ST_Execute			: BOOL;
	ST_Complete			: BOOL;
	ST_Idle				: BOOL;
	ST_Held				: BOOL;
	ST_Suspended		: BOOL;
	ST_Stopped			: BOOL;
	ST_Aborted			: BOOL;

	(* additional *)
	Error				: BOOL;
	ErrorID				: DWORD;
	ePMLState			: E_PMLState := ePMLState_IDLE;
END_VAR
VAR
	ePMLStatePrev		: E_PMLState;
	bStateChange		: BOOL;
	StateCompletePrev	: BOOL;
END_VAR

(* check for state change *)
IF ePMLStatePrev <> ePMLState THEN
	ePMLStatePrev 	:= ePMLState;
	bStateChange	:= TRUE;
ELSE
	bStateChange	:= FALSE;
END_IF


(* change to new state if requested *)
CASE ePMLState OF
	ePMLState_UNDEFINED:
		(* undefined state *)
		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Stopping		:= TRUE;
		END_IF


	ePMLState_IDLE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= TRUE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Idle			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Idle			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Start THEN
			ePMLState 		:= ePMLState_STARTING;
			ST_Idle			:= FALSE;
			ST_Starting		:= TRUE;
		END_IF


	ePMLState_STARTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= TRUE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Starting		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Starting		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_Starting		:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_EXECUTE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= TRUE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Execute		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Execute		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Suspend THEN
			ePMLState 		:= ePMLState_SUSPENDING;
			ST_Execute		:= FALSE;
			ST_Suspending	:= TRUE;
		ELSIF Hold THEN
			ePMLState 		:= ePMLState_HOLDING;
			ST_Execute		:= FALSE;
			ST_Holding		:= TRUE;
		ELSIF Complete THEN
			ePMLState 		:= ePMLState_COMPLETING;
			ST_Execute		:= FALSE;
			ST_Completing	:= TRUE;
		END_IF


	ePMLState_COMPLETING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= TRUE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Completing	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Completing	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_COMPLETE;
			StateCompletePrev := StateComplete;
			ST_Completing	:= FALSE;
			ST_Complete		:= TRUE;
		END_IF


	ePMLState_COMPLETE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= TRUE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Complete		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Complete		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Reset THEN
			ePMLState 		:= ePMLState_RESETTING;
			ST_Complete		:= FALSE;
			ST_Resetting	:= TRUE;
		END_IF


	ePMLState_RESETTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= TRUE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Resetting	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Resetting	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete THEN
			ePMLState 		:= ePMLState_IDLE;
			StateCompletePrev := StateComplete;
			ST_Resetting	:= FALSE;
			ST_Idle			:= TRUE;
		END_IF


	ePMLState_HOLDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= TRUE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Holding		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Holding		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_HELD;
			StateCompletePrev := StateComplete;
			ST_Holding		:= FALSE;
			ST_Held			:= TRUE;
		END_IF


	ePMLState_HELD:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= TRUE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Held			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Held			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF UnHold THEN
			ePMLState 		:= ePMLState_UNHOLDING;
			ST_Held			:= FALSE;
			ST_UnHolding	:= TRUE;
		END_IF


	ePMLState_UNHOLDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= TRUE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_UnHolding	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_UnHolding	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_UnHolding	:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_SUSPENDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= TRUE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Suspending	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Suspending	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_SUSPENDED;
			StateCompletePrev := StateComplete;
			ST_Suspending	:= FALSE;
			ST_Suspended	:= TRUE;
		END_IF


	ePMLState_SUSPENDED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= TRUE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Suspended	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Suspended	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF UnSuspend THEN
			ePMLState 		:= ePMLState_UNSUSPENDING;
			ST_Suspended	:= FALSE;
			ST_UnSuspending	:= TRUE;
		END_IF


	ePMLState_UNSUSPENDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= TRUE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_UnSuspending	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_UnSuspending	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_UnSuspending	:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_STOPPING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= TRUE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			StateCompletePrev := StateComplete;
			ST_Stopping		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF


	ePMLState_STOPPED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= TRUE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Reset THEN
			ePMLState 		:= ePMLState_RESETTING;
			ST_Stopped		:= FALSE;
			ST_Resetting	:= TRUE;
		END_IF


ePMLState_ABORTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_ABORTED;
			StateCompletePrev := StateComplete;
			ST_Aborting		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF


	ePMLState_ABORTED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF

		IF Clear THEN
			ePMLState 		:= ePMLState_CLEARING;
			ST_Aborted		:= FALSE;
			ST_Clearing		:= TRUE;
		END_IF


	ePMLState_CLEARING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= TRUE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			StateCompletePrev := StateComplete;
			ST_Clearing		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF

END_CASE

(* auto clear with StateComplete = FALSE *)
StateCompletePrev := StateCompletePrev AND StateComplete;

END_FUNCTION_BLOCK

// ---- POUs/Internal PackAL/PS_PackML_StateMachine_SemiAuto.TcPOU
FUNCTION_BLOCK PS_PackML_StateMachine_SemiAuto
VAR_IN_OUT
	Machine				: Machine_REF;
END_VAR
VAR_INPUT
	Start				: BOOL;
	Hold				: BOOL;
	UnHold				: BOOL;
	Suspend				: BOOL;
	UnSuspend			: BOOL;
	Abort				: BOOL;
	Stop				: BOOL;
	Complete			: BOOL;
	Clear				: BOOL;
	Reset				: BOOL;
	StateComplete		: BOOL;
END_VAR
VAR_OUTPUT
	Status				: WORD;

	ST_Starting			: BOOL;
	ST_Completing		: BOOL;
	ST_Resetting		: BOOL;
	ST_Holding			: BOOL;
	ST_UnHolding		: BOOL;
	ST_Suspending		: BOOL;
	ST_UnSuspending		: BOOL;
	ST_Clearing			: BOOL;
	ST_Stopping			: BOOL;
	ST_Aborting			: BOOL;

	(* State Complete*)
	ST_Execute			: BOOL;
	ST_Complete			: BOOL;
	ST_Idle				: BOOL;
	ST_Held				: BOOL;
	ST_Suspended		: BOOL;
	ST_Stopped			: BOOL;
	ST_Aborted			: BOOL;

	(* additional *)
	Error				: BOOL;
	ErrorID				: DWORD;
	ePMLState			: E_PMLState := ePMLState_IDLE;
END_VAR
VAR
	ePMLStatePrev		: E_PMLState;
	bStateChange		: BOOL;
	StateCompletePrev	: BOOL;
END_VAR

IF ePMLStatePrev <> ePMLState THEN
	ePMLStatePrev 	:= ePMLState;
	bStateChange	:= TRUE;
ELSE
	bStateChange	:= FALSE;
END_IF


(* change to new state if requested *)
CASE ePMLState OF
	ePMLState_UNDEFINED:
		(* undefined state *)
		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Stopping		:= TRUE;
		END_IF


	ePMLState_IDLE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= TRUE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 	:= ePMLState_ABORTING;
			ST_Idle			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 	:= ePMLState_STOPPING;
			ST_Idle			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Start THEN
			ePMLState 	:= ePMLState_STARTING;
			ST_Idle			:= FALSE;
			ST_Starting		:= TRUE;
		END_IF


	ePMLState_STARTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= TRUE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Starting		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Starting		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_Starting		:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_EXECUTE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= TRUE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Execute		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Execute		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Suspend THEN
			ePMLState 		:= ePMLState_SUSPENDING;
			ST_Execute		:= FALSE;
			ST_Suspending	:= TRUE;
		ELSIF Hold THEN
			ePMLState 		:= ePMLState_HOLDING;
			ST_Execute		:= FALSE;
			ST_Holding		:= TRUE;
		ELSIF Complete THEN
			ePMLState 		:= ePMLState_COMPLETING;
			ST_Execute		:= FALSE;
			ST_Completing	:= TRUE;
		END_IF


	ePMLState_COMPLETING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= TRUE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Completing	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Completing	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_COMPLETE;
			StateCompletePrev := StateComplete;
			ST_Completing	:= FALSE;
			ST_Complete		:= TRUE;
		END_IF


	ePMLState_COMPLETE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= TRUE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Complete		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Complete		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Reset THEN
			ePMLState 		:= ePMLState_RESETTING;
			ST_Complete		:= FALSE;
			ST_Resetting	:= TRUE;
		END_IF


	ePMLState_RESETTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= TRUE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Resetting	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Resetting	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_IDLE;
			StateCompletePrev := StateComplete;
			ST_Resetting	:= FALSE;
			ST_Idle			:= TRUE;
		END_IF


	ePMLState_HOLDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= TRUE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Holding		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Holding		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_HELD;
			StateCompletePrev := StateComplete;
			ST_Holding		:= FALSE;
			ST_Held			:= TRUE;
		END_IF


	ePMLState_HELD:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= TRUE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Held			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Held			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF UnHold THEN
			ePMLState 		:= ePMLState_UNHOLDING;
			ST_Held			:= FALSE;
			ST_UnHolding	:= TRUE;
		END_IF


	ePMLState_UNHOLDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= TRUE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_UnHolding	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_UnHolding	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_UnHolding	:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_SUSPENDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= TRUE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Suspending	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Suspending	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_SUSPENDED;
			StateCompletePrev := StateComplete;
			ST_Suspending	:= FALSE;
			ST_Suspended	:= TRUE;
		END_IF


	ePMLState_SUSPENDED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= TRUE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Suspended	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Suspended	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF UnSuspend THEN
			ePMLState 		:= ePMLState_UNSUSPENDING;
			ST_Suspended	:= FALSE;
			ST_UnSuspending	:= TRUE;
		END_IF


	ePMLState_UNSUSPENDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= TRUE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_UnSuspending	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_UnSuspending	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_UnSuspending	:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_STOPPING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= TRUE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			StateCompletePrev := StateComplete;
			ST_Stopping		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF


	ePMLState_STOPPED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= TRUE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Reset THEN
			ePMLState 		:= ePMLState_RESETTING;
			ST_Stopped		:= FALSE;
			ST_Resetting	:= TRUE;
		END_IF


ePMLState_ABORTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_ABORTED;
			StateCompletePrev := StateComplete;
			ST_Aborting		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF


	ePMLState_ABORTED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF

		IF Clear THEN
			ePMLState 		:= ePMLState_CLEARING;
			ST_Aborted		:= FALSE;
			ST_Clearing		:= TRUE;
		END_IF


	ePMLState_CLEARING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= TRUE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			StateCompletePrev := StateComplete;
			ST_Clearing		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF

END_CASE

(* auto clear with StateComplete = FALSE *)
StateCompletePrev := StateCompletePrev AND StateComplete;

END_FUNCTION_BLOCK

// ---- POUs/Internal PackAL/PS_PackML_StateMachine_Manual.TcPOU
FUNCTION_BLOCK PS_PackML_StateMachine_Manual
VAR_IN_OUT
	Machine				: Machine_REF;
END_VAR
VAR_INPUT
	Start				: BOOL;
	Hold				: BOOL;
	UnHold				: BOOL;
	Suspend				: BOOL;
	UnSuspend			: BOOL;
	Abort				: BOOL;
	Stop				: BOOL;
	Complete			: BOOL;
	Clear				: BOOL;
	Reset				: BOOL;
	StateComplete		: BOOL;
END_VAR
VAR_OUTPUT
	Status				: WORD;

	ST_Starting			: BOOL;
	ST_Completing		: BOOL;
	ST_Resetting		: BOOL;
	ST_Holding			: BOOL;
	ST_UnHolding		: BOOL;
	ST_Suspending		: BOOL;
	ST_UnSuspending		: BOOL;
	ST_Clearing			: BOOL;
	ST_Stopping			: BOOL;
	ST_Aborting			: BOOL;

	(* State Complete*)
	ST_Execute			: BOOL;
	ST_Complete			: BOOL;
	ST_Idle				: BOOL;
	ST_Held				: BOOL;
	ST_Suspended		: BOOL;
	ST_Stopped			: BOOL;
	ST_Aborted			: BOOL;

	(* additional *)
	Error				: BOOL;
	ErrorID				: DWORD;
	ePMLState			: E_PMLState := ePMLState_IDLE;
END_VAR
VAR
	ePMLStatePrev		: E_PMLState;
	bStateChange		: BOOL;
	StateCompletePrev	: BOOL;
END_VAR

(* check for state change *)
IF ePMLStatePrev <> ePMLState THEN
	ePMLStatePrev 	:= ePMLState;
	bStateChange		:= TRUE;
ELSE
	bStateChange		:= FALSE;
END_IF


(* change to new state if requested *)
CASE ePMLState OF
	ePMLState_UNDEFINED:
		(* undefined state *)
		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Stopping		:= TRUE;
		END_IF


	ePMLState_IDLE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= TRUE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Idle			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Idle			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Start THEN
			ePMLState 		:= ePMLState_STARTING;
			ST_Idle			:= FALSE;
			ST_Starting		:= TRUE;
		END_IF


	ePMLState_STARTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= TRUE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Starting		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Starting		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_Starting		:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_EXECUTE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= TRUE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 	:= ePMLState_ABORTING;
			ST_Execute		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 	:= ePMLState_STOPPING;
			ST_Execute		:= FALSE;
			ST_Stopping		:= TRUE;
		END_IF


	ePMLState_RESETTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= TRUE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Resetting	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Resetting	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_IDLE;
			StateCompletePrev := StateComplete;
			ST_Resetting	:= FALSE;
			ST_Idle			:= TRUE;
		END_IF


	ePMLState_STOPPING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= TRUE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			StateCompletePrev := StateComplete;
			ST_Stopping		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF


	ePMLState_STOPPED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= TRUE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Reset THEN
			ePMLState 		:= ePMLState_RESETTING;
			ST_Stopped		:= FALSE;
			ST_Resetting	:= TRUE;
		END_IF


ePMLState_ABORTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_ABORTED;
			StateCompletePrev := StateComplete;
			ST_Aborting		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF


	ePMLState_ABORTED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF

		IF Clear THEN
			ePMLState 	:= ePMLState_CLEARING;
			ST_Aborted		:= FALSE;
			ST_Clearing		:= TRUE;
		END_IF


	ePMLState_CLEARING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= TRUE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			ST_Clearing		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF

END_CASE

(* auto clear with StateComplete = FALSE *)
StateCompletePrev := StateCompletePrev AND StateComplete;

END_FUNCTION_BLOCK

// ---- POUs/Internal PackAL/PS_PackML_StateMachine_Maintenance.TcPOU
FUNCTION_BLOCK PS_PackML_StateMachine_Maintenance
VAR_IN_OUT
	Machine				: Machine_REF;
END_VAR
VAR_INPUT
	Start				: BOOL;
	Hold				: BOOL;
	UnHold				: BOOL;
	Suspend				: BOOL;
	UnSuspend			: BOOL;
	Abort				: BOOL;
	Stop				: BOOL;
	Complete			: BOOL;
	Clear				: BOOL;
	Reset				: BOOL;
	StateComplete		: BOOL;
END_VAR
VAR_OUTPUT
	Status				: WORD;

	ST_Starting			: BOOL;
	ST_Completing		: BOOL;
	ST_Resetting		: BOOL;
	ST_Holding			: BOOL;
	ST_UnHolding		: BOOL;
	ST_Suspending		: BOOL;
	ST_UnSuspending		: BOOL;
	ST_Clearing			: BOOL;
	ST_Stopping			: BOOL;
	ST_Aborting			: BOOL;

	(* State Complete*)
	ST_Execute			: BOOL;
	ST_Complete			: BOOL;
	ST_Idle				: BOOL;
	ST_Held				: BOOL;
	ST_Suspended		: BOOL;
	ST_Stopped			: BOOL;
	ST_Aborted			: BOOL;

	(* additional *)
	Error				: BOOL;
	ErrorID				: DWORD;
	ePMLState			: E_PMLState := ePMLState_IDLE;
END_VAR
VAR
	ePMLStatePrev		: E_PMLState;
	bStateChange		: BOOL;
	StateCompletePrev	: BOOL;
END_VAR

(* check for state change *)
IF ePMLStatePrev <> ePMLState THEN
	ePMLStatePrev 	:= ePMLState;
	bStateChange	:= TRUE;
ELSE
	bStateChange	:= FALSE;
END_IF


(* change to new state if requested *)
CASE ePMLState OF
	ePMLState_UNDEFINED:
		(* undefined state *)
		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Stopping		:= TRUE;
		END_IF


	ePMLState_IDLE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= TRUE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Idle			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Idle			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Start THEN
			ePMLState 		:= ePMLState_STARTING;
			ST_Idle			:= FALSE;
			ST_Starting		:= TRUE;
		END_IF


	ePMLState_STARTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= TRUE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Starting		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Starting		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_Starting		:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_EXECUTE:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= TRUE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Execute		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Execute		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF Hold THEN
			ePMLState 		:= ePMLState_HOLDING;
			ST_Execute		:= FALSE;
			ST_Holding		:= TRUE;
		END_IF


	ePMLState_RESETTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= TRUE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Resetting	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Resetting	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_IDLE;
			StateCompletePrev := StateComplete;
			ST_Resetting	:= FALSE;
			ST_Idle			:= TRUE;
		END_IF


	ePMLState_HOLDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= TRUE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Holding		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Holding		:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_HELD;
			StateCompletePrev := StateComplete;
			ST_Holding		:= FALSE;
			ST_Held			:= TRUE;
		END_IF


	ePMLState_HELD:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= TRUE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Held			:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_Held			:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF UnHold THEN
			ePMLState 		:= ePMLState_UNHOLDING;
			ST_Held			:= FALSE;
			ST_UnHolding	:= TRUE;
		END_IF


	ePMLState_UNHOLDING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= TRUE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_UnHolding	:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Stop THEN
			ePMLState 		:= ePMLState_STOPPING;
			ST_UnHolding	:= FALSE;
			ST_Stopping		:= TRUE;
		ELSIF StateComplete THEN
			ePMLState 		:= ePMLState_EXECUTE;
			StateCompletePrev := StateComplete;
			ST_UnHolding	:= FALSE;
			ST_Execute		:= TRUE;
		END_IF


	ePMLState_STOPPING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= TRUE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			StateCompletePrev := StateComplete;
			ST_Stopping		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF


	ePMLState_STOPPED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= TRUE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF Reset THEN
			ePMLState 		:= ePMLState_RESETTING;
			ST_Stopped		:= FALSE;
			ST_Resetting	:= TRUE;
		END_IF


ePMLState_ABORTING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= TRUE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_ABORTED;
			StateCompletePrev := StateComplete;
			ST_Aborting		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF


	ePMLState_ABORTED:
		(* final state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= FALSE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= TRUE;
		END_IF

		IF Clear THEN
			ePMLState 		:= ePMLState_CLEARING;
			ST_Aborted		:= FALSE;
			ST_Clearing		:= TRUE;
		END_IF


	ePMLState_CLEARING:
		(* transient state *)

		IF bStateChange THEN
			(* transient state *)
			ST_Starting		:= FALSE;
			ST_Completing	:= FALSE;
			ST_Resetting	:= FALSE;
			ST_Holding		:= FALSE;
			ST_UnHolding	:= FALSE;
			ST_Suspending	:= FALSE;
			ST_UnSuspending	:= FALSE;
			ST_Clearing		:= TRUE;
			ST_Stopping		:= FALSE;
			ST_Aborting		:= FALSE;

			(* final state *)
			ST_Execute		:= FALSE;
			ST_Complete		:= FALSE;
			ST_Idle			:= FALSE;
			ST_Held			:= FALSE;
			ST_Suspended	:= FALSE;
			ST_Stopped		:= FALSE;
			ST_Aborted		:= FALSE;
		END_IF

		IF Abort THEN
			ePMLState 		:= ePMLState_ABORTING;
			ST_Stopped		:= FALSE;
			ST_Aborting		:= TRUE;
		ELSIF StateComplete AND NOT StateCompletePrev THEN
			ePMLState 		:= ePMLState_STOPPED;
			ST_Clearing		:= FALSE;
			ST_Stopped		:= TRUE;
		END_IF

END_CASE

(* auto clear with StateComplete = FALSE *)
StateCompletePrev := StateCompletePrev AND StateComplete;

END_FUNCTION_BLOCK

// ---- POUs/Internal PackAL/PS_UnitModeManager.TcPOU
FUNCTION_BLOCK PS_UnitModeManager
VAR_INPUT
	Execute 		: BOOL;
	eModeCommand 	: E_PMLUnitMode;
	ePMLState		: E_PMLState;
END_VAR
VAR_OUTPUT
	eModeStatus 	: E_PMLUnitMode;
	Done 			: BOOL;
	Error 			: BOOL;
	ErrorID 		: UDINT;
END_VAR
VAR
	rTrig			: R_TRIG;
END_VAR

rTrig(CLK:= Execute);

IF rTrig.Q THEN (* rising edge Execute *)
	Done := FALSE;
	Error := FALSE;
	ErrorID := 0;

     CASE eModeStatus OF
           ePMLUnitMode_UNDEFINED:
                eModeStatus := eModeCommand;
                Done := TRUE;

		ePMLUnitMode_AUTOMATIC:
			IF (ePMLState = ePMLState_STOPPED) OR (ePMLState = ePMLState_ABORTED) OR (ePMLState = ePMLState_IDLE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSIF ((ePMLState = ePMLState_SUSPENDED) OR (ePMLState = ePMLState_HELD) OR (ePMLState = ePMLState_COMPLETE))
				AND (eModeCommand = ePMLUnitMode_SEMIAUTOMATIC) THEN

				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSIF (ePMLState = ePMLState_HELD) AND (eModeCommand = ePMLUnitMode_MAINTENANCE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSE
				Error := TRUE;
				ErrorID := 1;
			END_IF

		ePMLUnitMode_MAINTENANCE:
			IF (ePMLState = ePMLState_STOPPED) OR (ePMLState = ePMLState_ABORTED) OR (ePMLState = ePMLState_IDLE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSIF (ePMLState = ePMLState_HELD) AND ((eModeCommand = ePMLUnitMode_AUTOMATIC) OR (eModeCommand = ePMLUnitMode_SEMIAUTOMATIC)) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSE
				Error := TRUE;
				ErrorID := 1;
			END_IF

		ePMLUnitMode_MANUAL:
			IF (ePMLState = ePMLState_STOPPED) OR (ePMLState = ePMLState_ABORTED) OR (ePMLState = ePMLState_IDLE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSE
				Error := TRUE;
				ErrorID := 1;
			END_IF

		ePMLUnitMode_SEMIAUTOMATIC:
			IF (ePMLState = ePMLState_STOPPED) OR (ePMLState = ePMLState_ABORTED) OR (ePMLState = ePMLState_IDLE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSIF ((ePMLState = ePMLState_SUSPENDED) OR (ePMLState = ePMLState_HELD) OR (ePMLState = ePMLState_COMPLETE))
				AND (eModeCommand = ePMLUnitMode_AUTOMATIC) THEN

				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSIF (ePMLState = ePMLState_HELD) AND (eModeCommand = ePMLUnitMode_MAINTENANCE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSE
				Error := TRUE;
				ErrorID := 1;
			END_IF

		ePMLUnitMode_DRYRUN:
			eModeStatus := eModeCommand;
			Done := TRUE;

		ePMLUnitMode_USERMODE1:
			eModeStatus := eModeCommand;
			Done := TRUE;

		ePMLUnitMode_USERMODE2:
			eModeStatus := eModeCommand;
			Done := TRUE;

		ePMLUnitMode_IDLE:
			IF (ePMLState = ePMLState_STOPPED) OR (ePMLState = ePMLState_ABORTED) OR (ePMLState = ePMLState_IDLE) THEN
				eModeStatus := eModeCommand;
				Done := TRUE;
			ELSE
				Error := TRUE;
				ErrorID := 1;
			END_IF

           ePMLUnitMode_ESTOP:
                IF (ePMLState = ePMLState_STOPPED) OR (ePMLState = ePMLState_ABORTED) OR (ePMLState = ePMLState_IDLE) THEN
                     eModeStatus := eModeCommand;
                     Done := TRUE;
                ELSE
                     Error := TRUE;
                     ErrorID := 1;
                END_IF
     END_CASE
END_IF

 (* reset with bExecute = FALSE *)
 IF NOT Execute THEN
     Done := FALSE;
     Error := FALSE;
     ErrorID := 0;
 END_IF

END_FUNCTION_BLOCK

// ---- POUs/Signal handling/FB_SignalHandlingDelayEdges.TcPOU
FUNCTION_BLOCK FB_SignalHandlingDelayEdges EXTENDS FB_SignalHandlingDelay
VAR_OUTPUT
	bEdgeOn			: BOOL;
	bEdgeOff		: BOOL;
END_VAR
VAR
	rtrigEdgeOn		: R_TRIG;
	ftrigEdgeOff	: F_TRIG;
END_VAR

// =========================================================
;
// =========================================================

METHOD PUBLIC M_SetOutput
VAR_INPUT
END_VAR
// =========================================================
	// Calling method M_SetOutput of base class FB_InputSignalDelay via 'SUPER^.'
	
SUPER^.M_SetOutput();

// =========================================================
	// Edge on
	
rtrigEdgeOn(CLK := bInput);
bEdgeOn := rtrigEdgeOn.Q;

// =========================================================
	// Edge off
	
ftrigEdgeOff(CLK := bInput );	
bEdgeOff := ftrigEdgeOff.Q;

// =========================================================
END_METHOD

END_FUNCTION_BLOCK

// ---- VISUs/GlobalTextList.TcGTLO
TEXTLIST GlobalTextList
  12 = '\n\nCompressed\n\nair'
  30 = '%s'
  31 = 'A C C I D E N T'
  21 = 'Aborted'
  7 = 'Automatic'
  0 = 'Detection\nof metal'
  28 = 'Enable /\nDisable'
  29 = 'ERROR MESSAGES'
  19 = 'Execute'
  18 = 'Idle'
  1 = 'Light\nsensor'
  17 = 'Machine information\n\n\n\n\n\n\n\n'
  16 = 'MAIN SWITCH\n\nPOWER SUPPLY'
  10 = 'Maintenance'
  8 = 'Manual'
  11 = 'Mode options'
  13 = 'Move belt\n+'
  14 = 'Move belt\n-'
  15 = 'Move to\nwork position'
  27 = 'REQUESTS'
  5 = 'Reset'
  9 = 'Semi-\nAutomatic'
  3 = 'Start'
  6 = 'State options'
  26 = 'STATES'
  4 = 'Stop'
  20 = 'Stopped'
  24 = 'To Abort'
  25 = 'To Reset'
  22 = 'To Start'
  23 = 'To Stop'
  2 = 'TOP VIEW ON SORTING SYSTEM'
   = ''
END_TEXTLIST
