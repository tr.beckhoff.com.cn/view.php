TYPE Machine_REF :
STRUCT
	test : BOOL;
END_STRUCT
END_TYPE
