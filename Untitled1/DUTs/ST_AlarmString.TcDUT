TYPE ST_AlarmString :
STRUCT
	chinese:		STRING:='CN';
	english:		STRING:='EN';
END_STRUCT
END_TYPE
