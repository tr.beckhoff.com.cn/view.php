TYPE Alm_AlmMsg :
STRUCT
	CN:		WSTRING:="中文";
	EN:		STRING:='En';	
END_STRUCT
END_TYPE
