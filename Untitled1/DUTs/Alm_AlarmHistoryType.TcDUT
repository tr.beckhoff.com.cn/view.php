TYPE Alm_AlarmHistoryType :
STRUCT
  	EventMessage:            	WSTRING;
	EventId:					INT;
   	EventTime:               	DT;
END_STRUCT
END_TYPE
