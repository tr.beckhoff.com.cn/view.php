TYPE manualstep :
(
	moveoff:=0,
    jogB,
	jogF,
	homing ,
	MoveRel,
	MoveABS,
	MoveVel,
	stop
);
END_TYPE
