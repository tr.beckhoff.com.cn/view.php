{attribute 'Tc2GvlVarNames'}
VAR_GLOBAL
	DATA:						ST_States;	(*状态*)
END_VAR
