{attribute 'strict'}
TYPE FlyingState :
(
	F_INIT,
	F_ENABLE,
	F_PREPARE1,
	F_PREPARE2,
	F_COUPLE,
	F_SYNCHRONIZED,
	F_DECOUPLE,
	F_RESET,
	F_ERROR	
)UINT;
END_TYPE
