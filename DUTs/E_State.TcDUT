TYPE E_State :
(
    eState_InitiateStateMachine    :=0, 
	eState_ReadCPUTempertureInit   :=20, 
    eState_ReadCPUTemperture       :=21,    
    eState_IdleState               :=100   
);
END_TYPE
