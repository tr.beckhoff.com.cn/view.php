PROGRAM MAIN
VAR
END_VAR


CORRIDOR();

BATH();

KITCHEN();

LIVINGROOM();

DININGROOM();

BEDROOM();

PLCDBAutoLog();

END_PROGRAM
