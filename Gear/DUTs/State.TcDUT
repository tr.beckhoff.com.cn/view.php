TYPE State :
(
	Powering_Axes := 0,
	Calibrating_Master,
	Calibrating_Slave,
	Gearin_Axes,
	Moving_Master,
	GearOut_Axes,
	Stopping_Axes
);
END_TYPE
