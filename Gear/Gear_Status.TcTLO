TEXTLIST Gear_Status
  0 = '解耦状态'
  1 = '耦合状态'
   = ''
END_TEXTLIST
