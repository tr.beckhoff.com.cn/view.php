PROGRAM visu_control
VAR
	visible : ARRAY[1..6] OF BOOL;
	data: INT;
	i: INT;
END_VAR

FOR i:= 1 TO 6 DO 
	visible[i]:=FALSE;
END_FOR

	visible[1]:=TRUE;
	
	visible[data]:= TRUE;

END_PROGRAM
