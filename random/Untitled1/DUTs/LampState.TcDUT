TYPE LampState :
STRUCT
	ON		:	STRING;
	OFF		:	STRING;
	
END_STRUCT
END_TYPE
