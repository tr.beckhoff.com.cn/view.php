TYPE ST_Point :
STRUCT
	x	:	UINT;
	y	:	LREAL;
END_STRUCT
END_TYPE
