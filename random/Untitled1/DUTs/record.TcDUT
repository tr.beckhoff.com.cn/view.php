TYPE record :
STRUCT
	counter				:UINT;
	localSystemTime		:STRING;
	totalScore			:STRING;
	scoreState			:WSTRING;
	threeEachPoint		:STRING;

END_STRUCT
END_TYPE
