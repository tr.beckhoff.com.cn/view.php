VAR_GLOBAL
	Master  :axis_ref;
	Slave  :axis_ref;
END_VAR
