TYPE step :
(
	init,
	homing:=100,
	creating_cam:=200,
	camming:=300,
	insync:=400,
	error:=500,
	reset:=600
);
END_TYPE
