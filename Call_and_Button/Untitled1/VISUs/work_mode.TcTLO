TEXTLIST work_mode
  0 = '手动'
  1 = '自动'
   = ''
END_TEXTLIST
