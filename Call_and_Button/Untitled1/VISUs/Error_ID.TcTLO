TEXTLIST Error_ID
  0 = '未超时'
  1 = '下行超时'
  2 = '上行超时'
   = ''
END_TEXTLIST
